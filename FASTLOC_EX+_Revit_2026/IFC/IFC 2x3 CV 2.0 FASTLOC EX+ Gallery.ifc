Properties of the parts of a building model (IFC2X3), part 2 of 6

# IfcDistributionPort (1764)
Name | FlowDirection | Group
Port_961191_1 | SOURCEANDSINK | Domestic Cold Water 123
Port_961435_0 | SOURCEANDSINK | Domestic Cold Water 123
Port_961191_2 | SOURCEANDSINK | Domestic Cold Water 123
Port_961193_1 | SOURCEANDSINK | Domestic Cold Water 124
Port_961433_0 | SOURCEANDSINK | Domestic Cold Water 124
Port_961193_2 | SOURCEANDSINK | Domestic Cold Water 124
Port_961195_1 | SOURCEANDSINK | Domestic Cold Water 125
Port_961431_0 | SOURCEANDSINK | Domestic Cold Water 125
Port_961195_2 | SOURCEANDSINK | Domestic Cold Water 125
Port_961197_1 | SOURCEANDSINK | Domestic Cold Water 126
Port_961579_0 | SOURCEANDSINK | Domestic Cold Water 126
Port_961197_2 | SOURCEANDSINK | Domestic Cold Water 126
Port_961199_1 | SOURCEANDSINK | Domestic Cold Water 127
Port_961421_0 | SOURCEANDSINK | Domestic Cold Water 127
Port_961199_2 | SOURCEANDSINK | Domestic Cold Water 127
Port_961201_1 | SOURCEANDSINK | Domestic Cold Water 128
Port_961423_0 | SOURCEANDSINK | Domestic Cold Water 128
Port_961201_2 | SOURCEANDSINK | Domestic Cold Water 128
Port_961203_1 | SOURCEANDSINK | Domestic Cold Water 129
Port_961425_0 | SOURCEANDSINK | Domestic Cold Water 129
Port_961203_2 | SOURCEANDSINK | Domestic Cold Water 129
Port_961205_1 | SOURCEANDSINK | Domestic Cold Water 130
Port_961427_0 | SOURCEANDSINK | Domestic Cold Water 130
Port_961205_2 | SOURCEANDSINK | Domestic Cold Water 130
Port_961207_1 | SOURCEANDSINK | Domestic Cold Water 136
Port_961429_0 | SOURCEANDSINK | Domestic Cold Water 136
Port_961207_2 | SOURCEANDSINK | Domestic Cold Water 136
Port_961214_2 | SOURCEANDSINK | Domestic Cold Water 139
Port_961214_3 | SOURCEANDSINK | Domestic Cold Water 139
Port_961413_0 | SOURCEANDSINK | Domestic Cold Water 139
Port_961216_2 | SOURCEANDSINK | Domestic Cold Water 140
Port_961216_3 | SOURCEANDSINK | Domestic Cold Water 140
Port_961415_0 | SOURCEANDSINK | Domestic Cold Water 140
Port_961218_2 | SOURCEANDSINK | Domestic Cold Water 142
Port_961218_3 | SOURCEANDSINK | Domestic Cold Water 142
Port_961417_0 | SOURCEANDSINK | Domestic Cold Water 142
Port_961220_2 | SOURCEANDSINK | Domestic Cold Water 144
Port_961220_3 | SOURCEANDSINK | Domestic Cold Water 144
Port_961419_0 | SOURCEANDSINK | Domestic Cold Water 144
Port_961226_1 | SOURCEANDSINK | Domestic Cold Water 145
Port_961411_0 | SOURCEANDSINK | Domestic Cold Water 145
Port_961226_2 | SOURCEANDSINK | Domestic Cold Water 145
Port_961228_1 | SOURCEANDSINK | Domestic Cold Water 146
Port_961409_0 | SOURCEANDSINK | Domestic Cold Water 146
Port_961228_2 | SOURCEANDSINK | Domestic Cold Water 146
Port_961230_1 | SOURCEANDSINK | Domestic Cold Water 147
Port_961407_0 | SOURCEANDSINK | Domestic Cold Water 147
Port_961230_2 | SOURCEANDSINK | Domestic Cold Water 147
Port_961232_1 | SOURCEANDSINK | Domestic Cold Water 148
Port_961405_0 | SOURCEANDSINK | Domestic Cold Water 148
Port_961232_2 | SOURCEANDSINK | Domestic Cold Water 148
Port_961238_1 | SOURCEANDSINK | Domestic Cold Water 210
Port_961389_0 | SOURCEANDSINK | Domestic Cold Water 210
Port_961238_2 | SOURCEANDSINK | Domestic Cold Water 210
Port_961395_0 | SOURCEANDSINK | Domestic Cold Water 210
Port_961240_1 | SOURCEANDSINK | Domestic Cold Water 212
Port_961391_0 | SOURCEANDSINK | Domestic Cold Water 212
Port_961240_2 | SOURCEANDSINK | Domestic Cold Water 212
Port_961393_0 | SOURCEANDSINK | Domestic Cold Water 212
Port_961242_1 | SOURCEANDSINK | Domestic Cold Water 216
Port_961399_0 | SOURCEANDSINK | Domestic Cold Water 216
Port_961242_2 | SOURCEANDSINK | Domestic Cold Water 216
Port_961397_0 | SOURCEANDSINK | Domestic Cold Water 216
Port_961244_1 | SOURCEANDSINK | Domestic Cold Water 219
Port_961403_0 | SOURCEANDSINK | Domestic Cold Water 219
Port_961244_2 | SOURCEANDSINK | Domestic Cold Water 219
Port_961401_0 | SOURCEANDSINK | Domestic Cold Water 219
Port_961250_3 | SOURCEANDSINK | Domestic Cold Water 149
Port_961377_0 | SOURCEANDSINK | Domestic Cold Water 149
Port_961250_4 | SOURCEANDSINK | Domestic Cold Water 149
Port_961252_3 | SOURCEANDSINK | Domestic Cold Water 150
Port_961379_0 | SOURCEANDSINK | Domestic Cold Water 150
Port_961252_4 | SOURCEANDSINK | Domestic Cold Water 150
Port_961254_3 | SOURCEANDSINK | Domestic Cold Water 151
Port_961381_0 | SOURCEANDSINK | Domestic Cold Water 151
Port_961254_4 | SOURCEANDSINK | Domestic Cold Water 151
Port_961256_3 | SOURCEANDSINK | Domestic Cold Water 152
Port_961383_0 | SOURCEANDSINK | Domestic Cold Water 152
Port_961256_4 | SOURCEANDSINK | Domestic Cold Water 152
Port_961258_3 | SOURCEANDSINK | Domestic Cold Water 153
Port_961385_0 | SOURCEANDSINK | Domestic Cold Water 153
Port_961258_4 | SOURCEANDSINK | Domestic Cold Water 153
Port_961265_1 | SOURCEANDSINK | Domestic Cold Water 154
Port_961375_0 | SOURCEANDSINK | Domestic Cold Water 154
Port_961265_2 | SOURCEANDSINK | Domestic Cold Water 154
Port_961267_1 | SOURCEANDSINK | Domestic Cold Water 155
Port_961373_0 | SOURCEANDSINK | Domestic Cold Water 155
Port_961267_2 | SOURCEANDSINK | Domestic Cold Water 155
Port_961269_1 | SOURCEANDSINK | Domestic Cold Water 156
Port_961371_0 | SOURCEANDSINK | Domestic Cold Water 156
Port_961269_2 | SOURCEANDSINK | Domestic Cold Water 156
Port_961271_1 | SOURCEANDSINK | Domestic Cold Water 157
Port_961369_0 | SOURCEANDSINK | Domestic Cold Water 157
Port_961271_2 | SOURCEANDSINK | Domestic Cold Water 157
Port_961273_1 | SOURCEANDSINK | Domestic Cold Water 158
Port_961387_0 | SOURCEANDSINK | Domestic Cold Water 158
Port_961273_2 | SOURCEANDSINK | Domestic Cold Water 158
Port_961280_2 | SOURCEANDSINK | Domestic Cold Water 159
Port_961280_3 | SOURCEANDSINK | Domestic Cold Water 159
Port_961363_0 | SOURCEANDSINK | Domestic Cold Water 159
Port_961282_2 | SOURCEANDSINK | Domestic Cold Water 160
Port_961282_3 | SOURCEANDSINK | Domestic Cold Water 160
Port_961365_0 | SOURCEANDSINK | Domestic Cold Water 160
Port_961284_2 | SOURCEANDSINK | Domestic Cold Water 161
Port_961284_3 | SOURCEANDSINK | Domestic Cold Water 161
Port_961367_0 | SOURCEANDSINK | Domestic Cold Water 161
Port_961289_3 | SOURCEANDSINK
Port_961289_4 | SOURCEANDSINK
Port_961289_5 | SOURCEANDSINK
Port_961291_3 | SOURCEANDSINK
Port_961291_4 | SOURCEANDSINK
Port_961291_5 | SOURCEANDSINK
InPort_961293_1 | SINK | Domestic Cold Water 162
OutPort_961359_0 | SOURCE | Domestic Cold Water 162
InPort_961295_1 | SINK | Domestic Cold Water 163
OutPort_961361_0 | SOURCE | Domestic Cold Water 163
Port_961299_1 | SOURCEANDSINK | Domestic Cold Water 185
Port_961357_0 | SOURCEANDSINK | Domestic Cold Water 185
Port_961299_2 | SOURCEANDSINK | Domestic Cold Water 185
Port_961355_0 | SOURCEANDSINK | Domestic Cold Water 185
Port_961301_1 | SOURCEANDSINK | Domestic Cold Water 182
Port_961353_0 | SOURCEANDSINK | Domestic Cold Water 182
Port_961301_2 | SOURCEANDSINK | Domestic Cold Water 182
Port_961351_0 | SOURCEANDSINK | Domestic Cold Water 182
Port_961303_1 | SOURCEANDSINK | Domestic Cold Water 179
Port_961347_0 | SOURCEANDSINK | Domestic Cold Water 179
Port_961303_2 | SOURCEANDSINK | Domestic Cold Water 179
Port_961349_0 | SOURCEANDSINK | Domestic Cold Water 179
Port_961305_1 | SOURCEANDSINK | Domestic Cold Water 176
Port_961345_0 | SOURCEANDSINK | Domestic Cold Water 176
Port_961305_2 | SOURCEANDSINK | Domestic Cold Water 176
Port_961343_0 | SOURCEANDSINK | Domestic Cold Water 176
Port_961319_0 | SOURCEANDSINK | Domestic Cold Water 165
Port_961323_2 | SOURCEANDSINK | Domestic Cold Water 165
Port_961319_1 | SOURCEANDSINK | Domestic Cold Water 165
Port_961321_0 | SOURCEANDSINK | Domestic Cold Water 165
Port_961323_1 | SOURCEANDSINK | Domestic Cold Water 165
Port_961321_1 | SOURCEANDSINK | Domestic Cold Water 165
Port_961325_0 | SOURCEANDSINK | Domestic Cold Water 169
Port_961329_2 | SOURCEANDSINK | Domestic Cold Water 169
Port_961325_1 | SOURCEANDSINK | Domestic Cold Water 169
Port_961327_0 | SOURCEANDSINK | Domestic Cold Water 169
Port_961329_1 | SOURCEANDSINK | Domestic Cold Water 169
Port_961327_1 | SOURCEANDSINK | Domestic Cold Water 169
Port_961331_0 | SOURCEANDSINK | Domestic Cold Water 172
Port_961335_2 | SOURCEANDSINK | Domestic Cold Water 172
Port_961331_1 | SOURCEANDSINK | Domestic Cold Water 172
Port_961333_0 | SOURCEANDSINK | Domestic Cold Water 172
Port_961335_1 | SOURCEANDSINK | Domestic Cold Water 172
Port_961333_1 | SOURCEANDSINK | Domestic Cold Water 172
Port_961337_0 | SOURCEANDSINK | Domestic Cold Water 174
Port_961341_2 | SOURCEANDSINK | Domestic Cold Water 174
Port_961337_1 | SOURCEANDSINK | Domestic Cold Water 174
Port_961339_0 | SOURCEANDSINK | Domestic Cold Water 174
Port_961341_1 | SOURCEANDSINK | Domestic Cold Water 174
Port_961339_1 | SOURCEANDSINK | Domestic Cold Water 174
Port_961343_1 | SOURCEANDSINK | Domestic Cold Water 176
Port_961345_1 | SOURCEANDSINK | Domestic Cold Water 176
Port_961347_1 | SOURCEANDSINK | Domestic Cold Water 179
Port_961349_1 | SOURCEANDSINK | Domestic Cold Water 179
Port_961351_1 | SOURCEANDSINK | Domestic Cold Water 182
Port_961353_1 | SOURCEANDSINK | Domestic Cold Water 182
Port_961355_1 | SOURCEANDSINK | Domestic Cold Water 185
Port_961357_1 | SOURCEANDSINK | Domestic Cold Water 185
InPort_961359_1 | SINK | Domestic Cold Water 162
InPort_961361_1 | SINK | Domestic Cold Water 163
Port_961363_1 | SOURCEANDSINK | Domestic Cold Water 159
Port_961365_1 | SOURCEANDSINK | Domestic Cold Water 160
Port_961367_1 | SOURCEANDSINK | Domestic Cold Water 161
Port_961369_1 | SOURCEANDSINK | Domestic Cold Water 157
Port_961371_1 | SOURCEANDSINK | Domestic Cold Water 156
Port_961373_1 | SOURCEANDSINK | Domestic Cold Water 155
Port_961375_1 | SOURCEANDSINK | Domestic Cold Water 154
Port_961377_1 | SOURCEANDSINK | Domestic Cold Water 149
Port_961379_1 | SOURCEANDSINK | Domestic Cold Water 150
Port_961381_1 | SOURCEANDSINK | Domestic Cold Water 151
Port_961383_1 | SOURCEANDSINK | Domestic Cold Water 152
Port_961385_1 | SOURCEANDSINK | Domestic Cold Water 153
Port_961387_1 | SOURCEANDSINK | Domestic Cold Water 158
Port_961389_1 | SOURCEANDSINK | Domestic Cold Water 210
Port_961391_1 | SOURCEANDSINK | Domestic Cold Water 212
Port_961393_1 | SOURCEANDSINK | Domestic Cold Water 212
Port_961395_1 | SOURCEANDSINK | Domestic Cold Water 210
Port_961397_1 | SOURCEANDSINK | Domestic Cold Water 216
Port_961399_1 | SOURCEANDSINK | Domestic Cold Water 216
Port_961401_1 | SOURCEANDSINK | Domestic Cold Water 219
Port_961403_1 | SOURCEANDSINK | Domestic Cold Water 219
Port_961405_1 | SOURCEANDSINK | Domestic Cold Water 148
Port_961407_1 | SOURCEANDSINK | Domestic Cold Water 147
Port_961409_1 | SOURCEANDSINK | Domestic Cold Water 146
Port_961411_1 | SOURCEANDSINK | Domestic Cold Water 145
Port_961413_1 | SOURCEANDSINK | Domestic Cold Water 139
Port_961415_1 | SOURCEANDSINK | Domestic Cold Water 140
Port_961417_1 | SOURCEANDSINK | Domestic Cold Water 142
Port_961419_1 | SOURCEANDSINK | Domestic Cold Water 144
Port_961421_1 | SOURCEANDSINK | Domestic Cold Water 127
Port_961423_1 | SOURCEANDSINK | Domestic Cold Water 128
Port_961425_1 | SOURCEANDSINK | Domestic Cold Water 129
Port_961427_1 | SOURCEANDSINK | Domestic Cold Water 130
Port_961429_1 | SOURCEANDSINK | Domestic Cold Water 136
Port_961431_1 | SOURCEANDSINK | Domestic Cold Water 125
Port_961433_1 | SOURCEANDSINK | Domestic Cold Water 124
Port_961435_1 | SOURCEANDSINK | Domestic Cold Water 123
Port_961437_1 | SOURCEANDSINK | Domestic Cold Water 122
Port_961439_1 | SOURCEANDSINK | Domestic Cold Water 121
Port_961441_1 | SOURCEANDSINK | Domestic Cold Water 119
Port_961443_1 | SOURCEANDSINK | Domestic Cold Water 244
Port_961445_1 | SOURCEANDSINK | Domestic Cold Water 244
Port_961447_1 | SOURCEANDSINK | Domestic Cold Water 246
Port_961449_1 | SOURCEANDSINK | Domestic Cold Water 246
Port_961451_1 | SOURCEANDSINK | Domestic Cold Water 248
Port_961453_1 | SOURCEANDSINK | Domestic Cold Water 248
Port_961455_1 | SOURCEANDSINK | Domestic Cold Water 250
Port_961457_1 | SOURCEANDSINK | Domestic Cold Water 250
Port_961459_1 | SOURCEANDSINK | Domestic Cold Water 117
Port_961461_1 | SOURCEANDSINK | Domestic Cold Water 117
Port_961463_1 | SOURCEANDSINK | Domestic Cold Water 115
Port_961465_1 | SOURCEANDSINK | Domestic Cold Water 115
Port_961467_1 | SOURCEANDSINK | Domestic Cold Water 113
Port_961469_1 | SOURCEANDSINK | Domestic Cold Water 113
Port_961471_1 | SOURCEANDSINK | Domestic Cold Water 258
Port_961473_1 | SOURCEANDSINK | Domestic Cold Water 258
Port_961475_1 | SOURCEANDSINK | Domestic Cold Water 258
Port_961477_1 | SOURCEANDSINK | Domestic Cold Water 261
Port_961479_1 | SOURCEANDSINK | Domestic Cold Water 261
Port_961481_1 | SOURCEANDSINK | Domestic Cold Water 261
Port_961483_1 | SOURCEANDSINK | Domestic Cold Water 264
Port_961485_1 | SOURCEANDSINK | Domestic Cold Water 264
Port_961487_1 | SOURCEANDSINK | Domestic Cold Water 264
Port_961489_1 | SOURCEANDSINK | Domestic Cold Water 267
Port_961491_1 | SOURCEANDSINK | Domestic Cold Water 267
Port_961493_1 | SOURCEANDSINK | Domestic Cold Water 267
Port_961495_1 | SOURCEANDSINK | Domestic Cold Water 270
Port_961497_1 | SOURCEANDSINK | Domestic Cold Water 270
Port_961499_1 | SOURCEANDSINK | Domestic Cold Water 270
Port_961501_1 | SOURCEANDSINK | Domestic Cold Water 273
Port_961503_1 | SOURCEANDSINK | Domestic Cold Water 273
Port_961505_1 | SOURCEANDSINK | Domestic Cold Water 273
Port_961507_1 | SOURCEANDSINK | Domestic Cold Water 276
Port_961509_1 | SOURCEANDSINK | Domestic Cold Water 276
Port_961511_1 | SOURCEANDSINK | Domestic Cold Water 276
Port_961513_1 | SOURCEANDSINK | Domestic Cold Water 279
Port_961515_1 | SOURCEANDSINK | Domestic Cold Water 279
Port_961517_1 | SOURCEANDSINK | Domestic Cold Water 279
Port_961519_1 | SOURCEANDSINK | Domestic Cold Water 282
Port_961521_1 | SOURCEANDSINK | Domestic Cold Water 282
Port_961523_1 | SOURCEANDSINK | Domestic Cold Water 282
Port_961525_1 | SOURCEANDSINK | Domestic Cold Water 285
Port_961527_1 | SOURCEANDSINK | Domestic Cold Water 285
Port_961529_1 | SOURCEANDSINK | Domestic Cold Water 285
Port_961531_1 | SOURCEANDSINK | Domestic Cold Water 288
Port_961533_1 | SOURCEANDSINK | Domestic Cold Water 288
Port_961535_1 | SOURCEANDSINK | Domestic Cold Water 288
Port_961537_1 | SOURCEANDSINK | Domestic Cold Water 291
Port_961539_1 | SOURCEANDSINK | Domestic Cold Water 291
Port_961541_1 | SOURCEANDSINK | Domestic Cold Water 291
Port_961543_1 | SOURCEANDSINK | Domestic Cold Water 294
Port_961545_1 | SOURCEANDSINK | Domestic Cold Water 294
Port_961547_1 | SOURCEANDSINK | Domestic Cold Water 294
Port_961549_1 | SOURCEANDSINK | Domestic Cold Water 297
Port_961551_1 | SOURCEANDSINK | Domestic Cold Water 297
Port_961553_1 | SOURCEANDSINK | Domestic Cold Water 297
Port_961555_1 | SOURCEANDSINK | Domestic Cold Water 300
Port_961557_1 | SOURCEANDSINK | Domestic Cold Water 300
Port_961559_1 | SOURCEANDSINK | Domestic Cold Water 300
Port_961561_1 | SOURCEANDSINK | Domestic Cold Water 303
Port_961563_1 | SOURCEANDSINK | Domestic Cold Water 303
Port_961565_1 | SOURCEANDSINK | Domestic Cold Water 303
Port_961567_1 | SOURCEANDSINK | Domestic Cold Water 306
Port_961569_1 | SOURCEANDSINK | Domestic Cold Water 306
Port_961571_1 | SOURCEANDSINK | Domestic Cold Water 306
Port_961573_1 | SOURCEANDSINK | Domestic Cold Water 309
Port_961575_1 | SOURCEANDSINK | Domestic Cold Water 309
Port_961577_1 | SOURCEANDSINK | Domestic Cold Water 309
Port_961579_1 | SOURCEANDSINK | Domestic Cold Water 126
Port_961865_1 | SOURCEANDSINK | Domestic Cold Water 381
Port_962321_0 | SOURCEANDSINK | Domestic Cold Water 381
Port_961865_2 | SOURCEANDSINK | Domestic Cold Water 381
Port_962323_0 | SOURCEANDSINK | Domestic Cold Water 381
Port_961865_3 | SOURCEANDSINK | Domestic Cold Water 381
Port_962319_0 | SOURCEANDSINK | Domestic Cold Water 381
Port_961867_1 | SOURCEANDSINK | Domestic Cold Water 378
Port_962317_0 | SOURCEANDSINK | Domestic Cold Water 378
Port_961867_2 | SOURCEANDSINK | Domestic Cold Water 378
Port_962315_0 | SOURCEANDSINK | Domestic Cold Water 378
Port_961867_3 | SOURCEANDSINK | Domestic Cold Water 378
Port_962313_0 | SOURCEANDSINK | Domestic Cold Water 378
Port_961869_1 | SOURCEANDSINK | Domestic Cold Water 375
Port_962311_0 | SOURCEANDSINK | Domestic Cold Water 375
Port_961869_2 | SOURCEANDSINK | Domestic Cold Water 375
Port_962307_0 | SOURCEANDSINK | Domestic Cold Water 375
Port_961869_3 | SOURCEANDSINK | Domestic Cold Water 375
Port_962309_0 | SOURCEANDSINK | Domestic Cold Water 375
Port_961871_1 | SOURCEANDSINK | Domestic Cold Water 372
Port_962303_0 | SOURCEANDSINK | Domestic Cold Water 372
Port_961871_2 | SOURCEANDSINK | Domestic Cold Water 372
Port_962305_0 | SOURCEANDSINK | Domestic Cold Water 372
Port_961871_3 | SOURCEANDSINK | Domestic Cold Water 372
Port_962301_0 | SOURCEANDSINK | Domestic Cold Water 372
Port_961873_1 | SOURCEANDSINK | Domestic Cold Water 354
Port_962269_0 | SOURCEANDSINK | Domestic Cold Water 354
Port_961873_2 | SOURCEANDSINK | Domestic Cold Water 354
Port_962267_0 | SOURCEANDSINK | Domestic Cold Water 354
Port_961873_3 | SOURCEANDSINK | Domestic Cold Water 354
Port_962265_0 | SOURCEANDSINK | Domestic Cold Water 354
Port_961875_1 | SOURCEANDSINK | Domestic Cold Water 357
Port_962275_0 | SOURCEANDSINK | Domestic Cold Water 357
Port_961875_2 | SOURCEANDSINK | Domestic Cold Water 357
Port_962273_0 | SOURCEANDSINK | Domestic Cold Water 357
Port_961875_3 | SOURCEANDSINK | Domestic Cold Water 357
Port_962271_0 | SOURCEANDSINK | Domestic Cold Water 357
Port_961877_1 | SOURCEANDSINK | Domestic Cold Water 360
Port_962281_0 | SOURCEANDSINK | Domestic Cold Water 360
Port_961877_2 | SOURCEANDSINK | Domestic Cold Water 360
Port_962279_0 | SOURCEANDSINK | Domestic Cold Water 360
Port_961877_3 | SOURCEANDSINK | Domestic Cold Water 360
Port_962277_0 | SOURCEANDSINK | Domestic Cold Water 360
Port_961879_1 | SOURCEANDSINK | Domestic Cold Water 363
Port_962287_0 | SOURCEANDSINK | Domestic Cold Water 363
Port_961879_2 | SOURCEANDSINK | Domestic Cold Water 363
Port_962285_0 | SOURCEANDSINK | Domestic Cold Water 363
Port_961879_3 | SOURCEANDSINK | Domestic Cold Water 363
Port_962283_0 | SOURCEANDSINK | Domestic Cold Water 363
Port_961881_1 | SOURCEANDSINK | Domestic Cold Water 366
Port_962291_0 | SOURCEANDSINK | Domestic Cold Water 366
Port_961881_2 | SOURCEANDSINK | Domestic Cold Water 366
Port_962293_0 | SOURCEANDSINK | Domestic Cold Water 366
Port_961881_3 | SOURCEANDSINK | Domestic Cold Water 366
Port_962289_0 | SOURCEANDSINK | Domestic Cold Water 366
Port_961883_1 | SOURCEANDSINK | Domestic Cold Water 369
Port_962297_0 | SOURCEANDSINK | Domestic Cold Water 369
Port_961883_2 | SOURCEANDSINK | Domestic Cold Water 369
Port_962299_0 | SOURCEANDSINK | Domestic Cold Water 369
Port_961883_3 | SOURCEANDSINK | Domestic Cold Water 369
Port_962295_0 | SOURCEANDSINK | Domestic Cold Water 369
Port_961885_1 | SOURCEANDSINK | Domestic Cold Water 351
Port_962263_0 | SOURCEANDSINK | Domestic Cold Water 351
Port_961885_2 | SOURCEANDSINK | Domestic Cold Water 351
Port_962261_0 | SOURCEANDSINK | Domestic Cold Water 351
Port_961885_3 | SOURCEANDSINK | Domestic Cold Water 351
Port_962259_0 | SOURCEANDSINK | Domestic Cold Water 351
Port_961887_1 | SOURCEANDSINK | Domestic Cold Water 336
Port_962229_0 | SOURCEANDSINK | Domestic Cold Water 336
Port_961887_2 | SOURCEANDSINK | Domestic Cold Water 336
Port_962231_0 | SOURCEANDSINK | Domestic Cold Water 336
Port_961887_3 | SOURCEANDSINK | Domestic Cold Water 336
Port_962233_0 | SOURCEANDSINK | Domestic Cold Water 336
Port_961889_1 | SOURCEANDSINK | Domestic Cold Water 348
Port_962257_0 | SOURCEANDSINK | Domestic Cold Water 348
Port_961889_2 | SOURCEANDSINK | Domestic Cold Water 348
Port_962255_0 | SOURCEANDSINK | Domestic Cold Water 348
Port_961889_3 | SOURCEANDSINK | Domestic Cold Water 348
Port_962253_0 | SOURCEANDSINK | Domestic Cold Water 348
Port_961891_1 | SOURCEANDSINK | Domestic Cold Water 339
Port_962237_0 | SOURCEANDSINK | Domestic Cold Water 339
Port_961891_2 | SOURCEANDSINK | Domestic Cold Water 339
Port_962239_0 | SOURCEANDSINK | Domestic Cold Water 339
Port_961891_3 | SOURCEANDSINK | Domestic Cold Water 339
Port_962235_0 | SOURCEANDSINK | Domestic Cold Water 339
Port_961893_1 | SOURCEANDSINK | Domestic Cold Water 342
Port_962245_0 | SOURCEANDSINK | Domestic Cold Water 342
Port_961893_2 | SOURCEANDSINK | Domestic Cold Water 342
Port_962243_0 | SOURCEANDSINK | Domestic Cold Water 342
Port_961893_3 | SOURCEANDSINK | Domestic Cold Water 342
Port_962241_0 | SOURCEANDSINK | Domestic Cold Water 342
Port_961895_1 | SOURCEANDSINK | Domestic Cold Water 345
Port_962251_0 | SOURCEANDSINK | Domestic Cold Water 345
Port_961895_2 | SOURCEANDSINK | Domestic Cold Water 345
Port_962249_0 | SOURCEANDSINK | Domestic Cold Water 345
Port_961895_3 | SOURCEANDSINK | Domestic Cold Water 345
Port_962247_0 | SOURCEANDSINK | Domestic Cold Water 345
Port_961897_1 | SOURCEANDSINK | Domestic Cold Water 330
Port_962219_0 | SOURCEANDSINK | Domestic Cold Water 330
Port_961897_2 | SOURCEANDSINK | Domestic Cold Water 330
Port_962221_0 | SOURCEANDSINK | Domestic Cold Water 330
Port_961897_3 | SOURCEANDSINK | Domestic Cold Water 330
Port_962217_0 | SOURCEANDSINK | Domestic Cold Water 330
Port_961899_1 | SOURCEANDSINK | Domestic Cold Water 333
Port_962223_0 | SOURCEANDSINK | Domestic Cold Water 333
Port_961899_2 | SOURCEANDSINK | Domestic Cold Water 333
Port_962227_0 | SOURCEANDSINK | Domestic Cold Water 333
Port_961899_3 | SOURCEANDSINK | Domestic Cold Water 333
Port_962225_0 | SOURCEANDSINK | Domestic Cold Water 333
Port_961901_1 | SOURCEANDSINK | Domestic Cold Water 167
Port_962215_0 | SOURCEANDSINK | Domestic Cold Water 167
Port_961901_2 | SOURCEANDSINK | Domestic Cold Water 167
Port_962213_0 | SOURCEANDSINK | Domestic Cold Water 167
Port_961901_3 | SOURCEANDSINK | Domestic Cold Water 167
Port_961903_1 | SOURCEANDSINK | Domestic Cold Water 171
Port_962211_0 | SOURCEANDSINK | Domestic Cold Water 171
Port_961903_2 | SOURCEANDSINK | Domestic Cold Water 171
Port_962209_0 | SOURCEANDSINK | Domestic Cold Water 171
Port_961903_3 | SOURCEANDSINK | Domestic Cold Water 171
Port_961905_1 | SOURCEANDSINK | Domestic Cold Water 173
Port_962207_0 | SOURCEANDSINK | Domestic Cold Water 173
Port_961905_2 | SOURCEANDSINK | Domestic Cold Water 173
Port_962205_0 | SOURCEANDSINK | Domestic Cold Water 173
Port_961905_3 | SOURCEANDSINK | Domestic Cold Water 173
Port_961910_1 | SOURCEANDSINK | Domestic Cold Water 316
Port_962191_0 | SOURCEANDSINK | Domestic Cold Water 316
Port_961910_2 | SOURCEANDSINK | Domestic Cold Water 316
Port_962189_0 | SOURCEANDSINK | Domestic Cold Water 316
Port_961912_1 | SOURCEANDSINK | Domestic Cold Water 318
Port_962195_0 | SOURCEANDSINK | Domestic Cold Water 318
Port_961912_2 | SOURCEANDSINK | Domestic Cold Water 318
Port_962193_0 | SOURCEANDSINK | Domestic Cold Water 318
Port_961914_1 | SOURCEANDSINK | Domestic Cold Water 320
Port_962199_0 | SOURCEANDSINK | Domestic Cold Water 320
Port_961914_2 | SOURCEANDSINK | Domestic Cold Water 320
Port_962197_0 | SOURCEANDSINK | Domestic Cold Water 320
Port_961916_1 | SOURCEANDSINK | Domestic Cold Water 322
Port_962203_0 | SOURCEANDSINK | Domestic Cold Water 322
Port_961916_2 | SOURCEANDSINK | Domestic Cold Water 322
Port_962201_0 | SOURCEANDSINK | Domestic Cold Water 322
Port_961918_1 | SOURCEANDSINK | Domestic Cold Water 385
Port_962333_0 | SOURCEANDSINK | Domestic Cold Water 385
Port_961918_2 | SOURCEANDSINK | Domestic Cold Water 385
Port_962331_0 | SOURCEANDSINK | Domestic Cold Water 385
Port_961920_1 | SOURCEANDSINK | Domestic Cold Water 387
Port_962337_0 | SOURCEANDSINK | Domestic Cold Water 387
Port_961920_2 | SOURCEANDSINK | Domestic Cold Water 387
Port_962335_0 | SOURCEANDSINK | Domestic Cold Water 387
Port_961922_1 | SOURCEANDSINK | Domestic Cold Water 389
Port_962341_0 | SOURCEANDSINK | Domestic Cold Water 389
Port_961922_2 | SOURCEANDSINK | Domestic Cold Water 389
Port_962339_0 | SOURCEANDSINK | Domestic Cold Water 389
Port_961931_1 | SOURCEANDSINK | Domestic Cold Water 175
Port_962187_0 | SOURCEANDSINK | Domestic Cold Water 175
Port_961931_2 | SOURCEANDSINK | Domestic Cold Water 175
Port_961933_1 | SOURCEANDSINK | Domestic Cold Water 177
Port_962185_0 | SOURCEANDSINK | Domestic Cold Water 177
Port_961933_2 | SOURCEANDSINK | Domestic Cold Water 177
Port_961935_1 | SOURCEANDSINK | Domestic Cold Water 180
Port_962183_0 | SOURCEANDSINK | Domestic Cold Water 180
Port_961935_2 | SOURCEANDSINK | Domestic Cold Water 180
Port_961937_1 | SOURCEANDSINK | Domestic Cold Water 183
Port_962181_0 | SOURCEANDSINK | Domestic Cold Water 183
Port_961937_2 | SOURCEANDSINK | Domestic Cold Water 183
Port_961939_1 | SOURCEANDSINK | Domestic Cold Water 186
Port_962179_0 | SOURCEANDSINK | Domestic Cold Water 186
Port_961939_2 | SOURCEANDSINK | Domestic Cold Water 186
Port_961941_1 | SOURCEANDSINK | Domestic Cold Water 188
Port_962177_0 | SOURCEANDSINK | Domestic Cold Water 188
Port_961941_2 | SOURCEANDSINK | Domestic Cold Water 188
Port_961943_1 | SOURCEANDSINK | Domestic Cold Water 189
Port_962325_0 | SOURCEANDSINK | Domestic Cold Water 189
Port_961943_2 | SOURCEANDSINK | Domestic Cold Water 189
Port_961945_1 | SOURCEANDSINK | Domestic Cold Water 191
Port_962167_0 | SOURCEANDSINK | Domestic Cold Water 191
Port_961945_2 | SOURCEANDSINK | Domestic Cold Water 191
Port_961947_1 | SOURCEANDSINK | Domestic Cold Water 192
Port_962169_0 | SOURCEANDSINK | Domestic Cold Water 192
Port_961947_2 | SOURCEANDSINK | Domestic Cold Water 192
Port_961949_1 | SOURCEANDSINK | Domestic Cold Water 194
Port_962171_0 | SOURCEANDSINK | Domestic Cold Water 194
Port_961949_2 | SOURCEANDSINK | Domestic Cold Water 194
Port_961951_1 | SOURCEANDSINK | Domestic Cold Water 195
Port_962173_0 | SOURCEANDSINK | Domestic Cold Water 195
Port_961951_2 | SOURCEANDSINK | Domestic Cold Water 195
Port_961953_1 | SOURCEANDSINK | Domestic Cold Water 197
Port_962175_0 | SOURCEANDSINK | Domestic Cold Water 197
Port_961953_2 | SOURCEANDSINK | Domestic Cold Water 197
Port_961960_2 | SOURCEANDSINK | Domestic Cold Water 198
Port_961960_3 | SOURCEANDSINK | Domestic Cold Water 198
Port_962159_0 | SOURCEANDSINK | Domestic Cold Water 198
Port_961962_2 | SOURCEANDSINK | Domestic Cold Water 200
Port_961962_3 | SOURCEANDSINK | Domestic Cold Water 200
Port_962161_0 | SOURCEANDSINK | Domestic Cold Water 200
Port_961964_2 | SOURCEANDSINK | Domestic Cold Water 201
Port_961964_3 | SOURCEANDSINK | Domestic Cold Water 201
Port_962163_0 | SOURCEANDSINK | Domestic Cold Water 201
Port_961966_2 | SOURCEANDSINK | Domestic Cold Water 203
Port_961966_3 | SOURCEANDSINK | Domestic Cold Water 203
Port_962165_0 | SOURCEANDSINK | Domestic Cold Water 203
Port_961972_1 | SOURCEANDSINK | Domestic Cold Water 204
Port_962157_0 | SOURCEANDSINK | Domestic Cold Water 204
Port_961972_2 | SOURCEANDSINK | Domestic Cold Water 204
Port_961974_1 | SOURCEANDSINK | Domestic Cold Water 206
Port_962155_0 | SOURCEANDSINK | Domestic Cold Water 206
Port_961974_2 | SOURCEANDSINK | Domestic Cold Water 206
Port_961976_1 | SOURCEANDSINK | Domestic Cold Water 207
Port_962153_0 | SOURCEANDSINK | Domestic Cold Water 207
Port_961976_2 | SOURCEANDSINK | Domestic Cold Water 207
Port_961978_1 | SOURCEANDSINK | Domestic Cold Water 209
Port_962151_0 | SOURCEANDSINK | Domestic Cold Water 209
Port_961978_2 | SOURCEANDSINK | Domestic Cold Water 209
Port_961984_1 | SOURCEANDSINK | Domestic Cold Water 278
Port_962135_0 | SOURCEANDSINK | Domestic Cold Water 278
Port_961984_2 | SOURCEANDSINK | Domestic Cold Water 278
Port_962141_0 | SOURCEANDSINK | Domestic Cold Water 278
Port_961986_1 | SOURCEANDSINK | Domestic Cold Water 280
Port_962137_0 | SOURCEANDSINK | Domestic Cold Water 280
Port_961986_2 | SOURCEANDSINK | Domestic Cold Water 280
Port_962139_0 | SOURCEANDSINK | Domestic Cold Water 280
Port_961988_1 | SOURCEANDSINK | Domestic Cold Water 284
Port_962145_0 | SOURCEANDSINK | Domestic Cold Water 284
Port_961988_2 | SOURCEANDSINK | Domestic Cold Water 284
Port_962143_0 | SOURCEANDSINK | Domestic Cold Water 284
Port_961990_1 | SOURCEANDSINK | Domestic Cold Water 287
Port_962149_0 | SOURCEANDSINK | Domestic Cold Water 287
Port_961990_2 | SOURCEANDSINK | Domestic Cold Water 287
Port_962147_0 | SOURCEANDSINK | Domestic Cold Water 287
Port_961996_3 | SOURCEANDSINK | Domestic Cold Water 213
Port_962123_0 | SOURCEANDSINK | Domestic Cold Water 213
Port_961996_4 | SOURCEANDSINK | Domestic Cold Water 213
Port_961998_3 | SOURCEANDSINK | Domestic Cold Water 215
Port_962125_0 | SOURCEANDSINK | Domestic Cold Water 215
Port_961998_4 | SOURCEANDSINK | Domestic Cold Water 215
Port_962000_3 | SOURCEANDSINK | Domestic Cold Water 218
Port_962127_0 | SOURCEANDSINK | Domestic Cold Water 218
Port_962000_4 | SOURCEANDSINK | Domestic Cold Water 218
Port_962002_3 | SOURCEANDSINK | Domestic Cold Water 221
Port_962129_0 | SOURCEANDSINK | Domestic Cold Water 221
Port_962002_4 | SOURCEANDSINK | Domestic Cold Water 221
Port_962004_3 | SOURCEANDSINK | Domestic Cold Water 222
Port_962131_0 | SOURCEANDSINK | Domestic Cold Water 222
Port_962004_4 | SOURCEANDSINK | Domestic Cold Water 222
Port_962011_1 | SOURCEANDSINK | Domestic Cold Water 224
Port_962121_0 | SOURCEANDSINK | Domestic Cold Water 224
Port_962011_2 | SOURCEANDSINK | Domestic Cold Water 224
Port_962013_1 | SOURCEANDSINK | Domestic Cold Water 225
Port_962119_0 | SOURCEANDSINK | Domestic Cold Water 225
Port_962013_2 | SOURCEANDSINK | Domestic Cold Water 225
Port_962015_1 | SOURCEANDSINK | Domestic Cold Water 227
Port_962117_0 | SOURCEANDSINK | Domestic Cold Water 227
Port_962015_2 | SOURCEANDSINK | Domestic Cold Water 227
Port_962017_1 | SOURCEANDSINK | Domestic Cold Water 228
Port_962115_0 | SOURCEANDSINK | Domestic Cold Water 228
Port_962017_2 | SOURCEANDSINK | Domestic Cold Water 228
Port_962019_1 | SOURCEANDSINK | Domestic Cold Water 230
Port_962133_0 | SOURCEANDSINK | Domestic Cold Water 230
Port_962019_2 | SOURCEANDSINK | Domestic Cold Water 230
Port_962026_1 | SOURCEANDSINK | Domestic Cold Water 231
Port_962109_0 | SOURCEANDSINK | Domestic Cold Water 231
Port_962026_2 | SOURCEANDSINK | Domestic Cold Water 231
Port_962028_1 | SOURCEANDSINK | Domestic Cold Water 232
Port_962111_0 | SOURCEANDSINK | Domestic Cold Water 232
Port_962028_2 | SOURCEANDSINK | Domestic Cold Water 232
Port_962030_1 | SOURCEANDSINK | Domestic Cold Water 233
Port_962113_0 | SOURCEANDSINK | Domestic Cold Water 233
Port_962030_2 | SOURCEANDSINK | Domestic Cold Water 233
Port_962035_3 | SOURCEANDSINK
Port_962035_4 | SOURCEANDSINK
Port_962035_5 | SOURCEANDSINK
Port_962037_3 | SOURCEANDSINK
Port_962037_4 | SOURCEANDSINK
Port_962037_5 | SOURCEANDSINK
InPort_962039_1 | SINK | Domestic Cold Water 234
OutPort_962105_0 | SOURCE | Domestic Cold Water 234
InPort_962041_1 | SINK | Domestic Cold Water 235
OutPort_962107_0 | SOURCE | Domestic Cold Water 235
Port_962045_1 | SOURCEANDSINK | Domestic Cold Water 254
Port_962103_0 | SOURCEANDSINK | Domestic Cold Water 254
Port_962045_2 | SOURCEANDSINK | Domestic Cold Water 254
Port_962101_0 | SOURCEANDSINK | Domestic Cold Water 254
Port_962047_1 | SOURCEANDSINK | Domestic Cold Water 252
Port_962099_0 | SOURCEANDSINK | Domestic Cold Water 252
Port_962047_2 | SOURCEANDSINK | Domestic Cold Water 252
Port_962097_0 | SOURCEANDSINK | Domestic Cold Water 252
Port_962049_1 | SOURCEANDSINK | Domestic Cold Water 249
Port_962093_0 | SOURCEANDSINK | Domestic Cold Water 249
Port_962049_2 | SOURCEANDSINK | Domestic Cold Water 249
Port_962095_0 | SOURCEANDSINK | Domestic Cold Water 249
Port_962051_1 | SOURCEANDSINK | Domestic Cold Water 245
Port_962091_0 | SOURCEANDSINK | Domestic Cold Water 245
Port_962051_2 | SOURCEANDSINK | Domestic Cold Water 245
Port_962089_0 | SOURCEANDSINK | Domestic Cold Water 245
Port_962065_0 | SOURCEANDSINK | Domestic Cold Water 236
Port_962069_2 | SOURCEANDSINK | Domestic Cold Water 236
Port_962065_1 | SOURCEANDSINK | Domestic Cold Water 236
Port_962067_0 | SOURCEANDSINK | Domestic Cold Water 236
Port_962069_1 | SOURCEANDSINK | Domestic Cold Water 236
Port_962067_1 | SOURCEANDSINK | Domestic Cold Water 236
Port_962071_0 | SOURCEANDSINK | Domestic Cold Water 238
Port_962075_2 | SOURCEANDSINK | Domestic Cold Water 238
Port_962071_1 | SOURCEANDSINK | Domestic Cold Water 238
Port_962073_0 | SOURCEANDSINK | Domestic Cold Water 238
Port_962075_1 | SOURCEANDSINK | Domestic Cold Water 238
Port_962073_1 | SOURCEANDSINK | Domestic Cold Water 238
Port_962077_0 | SOURCEANDSINK | Domestic Cold Water 240
Port_962081_2 | SOURCEANDSINK | Domestic Cold Water 240
Port_962077_1 | SOURCEANDSINK | Domestic Cold Water 240
Port_962079_0 | SOURCEANDSINK | Domestic Cold Water 240
Port_962081_1 | SOURCEANDSINK | Domestic Cold Water 240
Port_962079_1 | SOURCEANDSINK | Domestic Cold Water 240
Port_962083_0 | SOURCEANDSINK | Domestic Cold Water 242
Port_962087_2 | SOURCEANDSINK | Domestic Cold Water 242
Port_962083_1 | SOURCEANDSINK | Domestic Cold Water 242
Port_962085_0 | SOURCEANDSINK | Domestic Cold Water 242
Port_962087_1 | SOURCEANDSINK | Domestic Cold Water 242
Port_962085_1 | SOURCEANDSINK | Domestic Cold Water 242
Port_962089_1 | SOURCEANDSINK | Domestic Cold Water 245
Port_962091_1 | SOURCEANDSINK | Domestic Cold Water 245
Port_962093_1 | SOURCEANDSINK | Domestic Cold Water 249
Port_962095_1 | SOURCEANDSINK | Domestic Cold Water 249
Port_962097_1 | SOURCEANDSINK | Domestic Cold Water 252
Port_962099_1 | SOURCEANDSINK | Domestic Cold Water 252
Port_962101_1 | SOURCEANDSINK | Domestic Cold Water 254
Port_962103_1 | SOURCEANDSINK | Domestic Cold Water 254
InPort_962105_1 | SINK | Domestic Cold Water 234
InPort_962107_1 | SINK | Domestic Cold Water 235
Port_962109_1 | SOURCEANDSINK | Domestic Cold Water 231
Port_962111_1 | SOURCEANDSINK | Domestic Cold Water 232
Port_962113_1 | SOURCEANDSINK | Domestic Cold Water 233
Port_962115_1 | SOURCEANDSINK | Domestic Cold Water 228
Port_962117_1 | SOURCEANDSINK | Domestic Cold Water 227
Port_962119_1 | SOURCEANDSINK | Domestic Cold Water 225
Port_962121_1 | SOURCEANDSINK | Domestic Cold Water 224
Port_962123_1 | SOURCEANDSINK | Domestic Cold Water 213
Port_962125_1 | SOURCEANDSINK | Domestic Cold Water 215
Port_962127_1 | SOURCEANDSINK | Domestic Cold Water 218
Port_962129_1 | SOURCEANDSINK | Domestic Cold Water 221
Port_962131_1 | SOURCEANDSINK | Domestic Cold Water 222
Port_962133_1 | SOURCEANDSINK | Domestic Cold Water 230
Port_962135_1 | SOURCEANDSINK | Domestic Cold Water 278
Port_962137_1 | SOURCEANDSINK | Domestic Cold Water 280
Port_962139_1 | SOURCEANDSINK | Domestic Cold Water 280
Port_962141_1 | SOURCEANDSINK | Domestic Cold Water 278
Port_962143_1 | SOURCEANDSINK | Domestic Cold Water 284
Port_962145_1 | SOURCEANDSINK | Domestic Cold Water 284
Port_962147_1 | SOURCEANDSINK | Domestic Cold Water 287
Port_962149_1 | SOURCEANDSINK | Domestic Cold Water 287
Port_962151_1 | SOURCEANDSINK | Domestic Cold Water 209
Port_962153_1 | SOURCEANDSINK | Domestic Cold Water 207
Port_962155_1 | SOURCEANDSINK | Domestic Cold Water 206
Port_962157_1 | SOURCEANDSINK | Domestic Cold Water 204
Port_962159_1 | SOURCEANDSINK | Domestic Cold Water 198
Port_962161_1 | SOURCEANDSINK | Domestic Cold Water 200
Port_962163_1 | SOURCEANDSINK | Domestic Cold Water 201
Port_962165_1 | SOURCEANDSINK | Domestic Cold Water 203
Port_962167_1 | SOURCEANDSINK | Domestic Cold Water 191
Port_962169_1 | SOURCEANDSINK | Domestic Cold Water 192
Port_962171_1 | SOURCEANDSINK | Domestic Cold Water 194
Port_962173_1 | SOURCEANDSINK | Domestic Cold Water 195
Port_962175_1 | SOURCEANDSINK | Domestic Cold Water 197
Port_962177_1 | SOURCEANDSINK | Domestic Cold Water 188
Port_962179_1 | SOURCEANDSINK | Domestic Cold Water 186
Port_962181_1 | SOURCEANDSINK | Domestic Cold Water 183
Port_962183_1 | SOURCEANDSINK | Domestic Cold Water 180
Port_962185_1 | SOURCEANDSINK | Domestic Cold Water 177
Port_962187_1 | SOURCEANDSINK | Domestic Cold Water 175
Port_962189_1 | SOURCEANDSINK | Domestic Cold Water 316
Port_962191_1 | SOURCEANDSINK | Domestic Cold Water 316
Port_962193_1 | SOURCEANDSINK | Domestic Cold Water 318
Port_962195_1 | SOURCEANDSINK | Domestic Cold Water 318
Port_962197_1 | SOURCEANDSINK | Domestic Cold Water 320
Port_962199_1 | SOURCEANDSINK | Domestic Cold Water 320
Port_962201_1 | SOURCEANDSINK | Domestic Cold Water 322
Port_962203_1 | SOURCEANDSINK | Domestic Cold Water 322
Port_962205_1 | SOURCEANDSINK | Domestic Cold Water 173
Port_962207_1 | SOURCEANDSINK | Domestic Cold Water 173
Port_962209_1 | SOURCEANDSINK | Domestic Cold Water 171
Port_962211_1 | SOURCEANDSINK | Domestic Cold Water 171
Port_962213_1 | SOURCEANDSINK | Domestic Cold Water 167
Port_962215_1 | SOURCEANDSINK | Domestic Cold Water 167
Port_962217_1 | SOURCEANDSINK | Domestic Cold Water 330
Port_962219_1 | SOURCEANDSINK | Domestic Cold Water 330
Port_962221_1 | SOURCEANDSINK | Domestic Cold Water 330
Port_962223_1 | SOURCEANDSINK | Domestic Cold Water 333
Port_962225_1 | SOURCEANDSINK | Domestic Cold Water 333
Port_962227_1 | SOURCEANDSINK | Domestic Cold Water 333
Port_962229_1 | SOURCEANDSINK | Domestic Cold Water 336
Port_962231_1 | SOURCEANDSINK | Domestic Cold Water 336
Port_962233_1 | SOURCEANDSINK | Domestic Cold Water 336
Port_962235_1 | SOURCEANDSINK | Domestic Cold Water 339
Port_962237_1 | SOURCEANDSINK | Domestic Cold Water 339
Port_962239_1 | SOURCEANDSINK | Domestic Cold Water 339
Port_962241_1 | SOURCEANDSINK | Domestic Cold Water 342
Port_962243_1 | SOURCEANDSINK | Domestic Cold Water 342
Port_962245_1 | SOURCEANDSINK | Domestic Cold Water 342
Port_962247_1 | SOURCEANDSINK | Domestic Cold Water 345
Port_962249_1 | SOURCEANDSINK | Domestic Cold Water 345
Port_962251_1 | SOURCEANDSINK | Domestic Cold Water 345
Port_962253_1 | SOURCEANDSINK | Domestic Cold Water 348
Port_962255_1 | SOURCEANDSINK | Domestic Cold Water 348
Port_962257_1 | SOURCEANDSINK | Domestic Cold Water 348
Port_962259_1 | SOURCEANDSINK | Domestic Cold Water 351
Port_962261_1 | SOURCEANDSINK | Domestic Cold Water 351
Port_962263_1 | SOURCEANDSINK | Domestic Cold Water 351
Port_962265_1 | SOURCEANDSINK | Domestic Cold Water 354
Port_962267_1 | SOURCEANDSINK | Domestic Cold Water 354
Port_962269_1 | SOURCEANDSINK | Domestic Cold Water 354
Port_962271_1 | SOURCEANDSINK | Domestic Cold Water 357
Port_962273_1 | SOURCEANDSINK | Domestic Cold Water 357
Port_962275_1 | SOURCEANDSINK | Domestic Cold Water 357
Port_962277_1 | SOURCEANDSINK | Domestic Cold Water 360
Port_962279_1 | SOURCEANDSINK | Domestic Cold Water 360
Port_962281_1 | SOURCEANDSINK | Domestic Cold Water 360
Port_962283_1 | SOURCEANDSINK | Domestic Cold Water 363
Port_962285_1 | SOURCEANDSINK | Domestic Cold Water 363
Port_962287_1 | SOURCEANDSINK | Domestic Cold Water 363
Port_962289_1 | SOURCEANDSINK | Domestic Cold Water 366
Port_962291_1 | SOURCEANDSINK | Domestic Cold Water 366
Port_962293_1 | SOURCEANDSINK | Domestic Cold Water 366
Port_962295_1 | SOURCEANDSINK | Domestic Cold Water 369
Port_962297_1 | SOURCEANDSINK | Domestic Cold Water 369
Port_962299_1 | SOURCEANDSINK | Domestic Cold Water 369
Port_962301_1 | SOURCEANDSINK | Domestic Cold Water 372
Port_962303_1 | SOURCEANDSINK | Domestic Cold Water 372
Port_962305_1 | SOURCEANDSINK | Domestic Cold Water 372
Port_962307_1 | SOURCEANDSINK | Domestic Cold Water 375
Port_962309_1 | SOURCEANDSINK | Domestic Cold Water 375
Port_962311_1 | SOURCEANDSINK | Domestic Cold Water 375
Port_962313_1 | SOURCEANDSINK | Domestic Cold Water 378
Port_962315_1 | SOURCEANDSINK | Domestic Cold Water 378
Port_962317_1 | SOURCEANDSINK | Domestic Cold Water 378
Port_962319_1 | SOURCEANDSINK | Domestic Cold Water 381
Port_962321_1 | SOURCEANDSINK | Domestic Cold Water 381
Port_962323_1 | SOURCEANDSINK | Domestic Cold Water 381
Port_962325_1 | SOURCEANDSINK | Domestic Cold Water 189
Port_962331_1 | SOURCEANDSINK | Domestic Cold Water 385
Port_962333_1 | SOURCEANDSINK | Domestic Cold Water 385
Port_962335_1 | SOURCEANDSINK | Domestic Cold Water 387
Port_962337_1 | SOURCEANDSINK | Domestic Cold Water 387
Port_962339_1 | SOURCEANDSINK | Domestic Cold Water 389
Port_962341_1 | SOURCEANDSINK | Domestic Cold Water 389
Port_963162_1 | SOURCEANDSINK | Domestic Cold Water 237
Port_963182_1 | SOURCEANDSINK | Domestic Cold Water 237
Port_963201_1 | SOURCEANDSINK | Domestic Cold Water 239
Port_963221_1 | SOURCEANDSINK | Domestic Cold Water 239
Port_963242_1 | SOURCEANDSINK | Domestic Cold Water 241
Port_963262_1 | SOURCEANDSINK | Domestic Cold Water 241
Port_963338_1 | SOURCEANDSINK | Domestic Cold Water 243
Port_963356_1 | SOURCEANDSINK | Domestic Cold Water 243
Port_963376_1 | SOURCEANDSINK | Domestic Cold Water 247
Port_963396_1 | SOURCEANDSINK | Domestic Cold Water 247
Port_963413_1 | SOURCEANDSINK | Domestic Cold Water 251
Port_963431_1 | SOURCEANDSINK | Domestic Cold Water 251

# IfcFlowFitting: FASTLOC Copper press adapter RX+:FSL RX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC Copper press adapter RX+; T1: FSL Copper press adapter RX+; T2: FSL Copper press adapter RX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL RX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC Copper press adapter RX+:FSL RX+ AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC Copper press adapter RX+; Family and Type: FASTLOC Copper press adapter RX+: FSL RX+ AT; Type: FSL RX+ AT; Type Id: 819424
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC Copper press adapter RX+:FSL RX+ AT:...) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906929 | 12 | 15 | 7.9 | 11 | 29 | 15 mmø-12 mmø | 0.00000929914 | 8.9 | REHAU Copper press adapter FASTLOC EX+ 16 - L15 | 4067936345458 | 13707411001 | 38 | Domestic Cold Water 92
906931 | 15 | 18 | 11.5 | 13.5 | 28 | 18 mmø-15 mmø | 0.0000157726 | 9.2 | REHAU Copper press adapter FASTLOC RX+ 20 - L18 | 4067936345465 | 13707441001 | 53 | Domestic Cold Water 93
906933 | 20 | 22 | 14.7 | 17.5 | 27.2 | 22 mmø-20 mmø | 0.000025997 | 10.6 | REHAU Copper press adapter FASTLOC RX+ 25 - L22 | 4067936345472 | 13707471001 | 81 | Domestic Cold Water 94
906935 | 25 | 28 | 19.7 | 23.5 | 31.1 | 28 mmø-25 mmø | 0.0000431714 | 13.1 | REHAU Copper press adapter FASTLOC RX+ 32 - L28 | 4067936345489 | 13707481001 | 142 | Domestic Cold Water 95
961972 | 12 | 15 | 7.9 | 11 | 29 | 15 mmø-12 mmø | 0.00000929914 | 8.9 | REHAU Copper press adapter FASTLOC EX+ 16 - L15 | 4067936345458 | 13707411001 | 38 | Domestic Cold Water 204
961974 | 15 | 18 | 11.5 | 13.5 | 28 | 18 mmø-15 mmø | 0.0000157726 | 9.2 | REHAU Copper press adapter FASTLOC RX+ 20 - L18 | 4067936345465 | 13707441001 | 53 | Domestic Cold Water 206
961976 | 20 | 22 | 14.7 | 17.5 | 27.2 | 22 mmø-20 mmø | 0.000025997 | 10.6 | REHAU Copper press adapter FASTLOC RX+ 25 - L22 | 4067936345472 | 13707471001 | 81 | Domestic Cold Water 207
961978 | 25 | 28 | 19.7 | 23.5 | 31.1 | 28 mmø-25 mmø | 0.0000431714 | 13.1 | REHAU Copper press adapter FASTLOC RX+ 32 - L28 | 4067936345489 | 13707481001 | 142 | Domestic Cold Water 209

# IfcFlowFitting: FASTLOC Copper press adapter RX+:FSL RX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC Copper press adapter RX+; T1: FSL Copper press adapter RX+; T2: FSL Copper press adapter RX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL RX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC Copper press adapter RX+:FSL RX+ DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC Copper press adapter RX+; Family and Type: FASTLOC Copper press adapter RX+: FSL RX+ DE; Type: FSL RX+ DE; Type Id: 825709
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC Copper press adapter RX+:FSL RX+ DE:...) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Description long | GTIN | PID | Weight | System Name = Group
839516 | 12 | 15 | 7.9 | 11 | 29 | 15 mmø-12 mmø | 0.00000929914 | 8.9 | REHAU Kupfer-Pressübergang FASTLOC RX+ 16 - L15 | 4067936345458 | 13707411001 | 38 | Domestic Cold Water 45
839614 | 15 | 18 | 11.5 | 13.5 | 28 | 18 mmø-15 mmø | 0.0000157726 | 9.2 | REHAU Kupfer-Pressübergang FASTLOC RX+ 20 - L18 | 4067936345465 | 13707441001 | 53 | Domestic Cold Water 46
839906 | 20 | 22 | 14.7 | 17.5 | 27.2 | 22 mmø-20 mmø | 0.000025997 | 10.6 | REHAU Kupfer-Pressübergang FASTLOC RX+ 25 - L22 | 4067936345472 | 13707471001 | 81 | Domestic Cold Water 47
839986 | 25 | 28 | 19.7 | 23.5 | 31.1 | 28 mmø-25 mmø | 0.0000431714 | 13.1 | REHAU Kupfer-Pressübergang FASTLOC RX+ 32 - L28 | 4067936345489 | 13707481001 | 142 | Domestic Cold Water 48
961226 | 12 | 15 | 7.9 | 11 | 29 | 15 mmø-12 mmø | 0.00000929914 | 8.9 | REHAU Kupfer-Pressübergang FASTLOC RX+ 16 - L15 | 4067936345458 | 13707411001 | 38 | Domestic Cold Water 145
961228 | 15 | 18 | 11.5 | 13.5 | 28 | 18 mmø-15 mmø | 0.0000157726 | 9.2 | REHAU Kupfer-Pressübergang FASTLOC RX+ 20 - L18 | 4067936345465 | 13707441001 | 53 | Domestic Cold Water 146
961230 | 20 | 22 | 14.7 | 17.5 | 27.2 | 22 mmø-20 mmø | 0.000025997 | 10.6 | REHAU Kupfer-Pressübergang FASTLOC RX+ 25 - L22 | 4067936345472 | 13707471001 | 81 | Domestic Cold Water 147
961232 | 25 | 28 | 19.7 | 23.5 | 31.1 | 28 mmø-25 mmø | 0.0000431714 | 13.1 | REHAU Kupfer-Pressübergang FASTLOC RX+ 32 - L28 | 4067936345489 | 13707481001 | 142 | Domestic Cold Water 148

# IfcFlowFitting: FASTLOC_ Backplate elbow short EX+:FSL Backplate elbow DE (6)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701, Polyvinyl Difluoride
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_ Backplate elbow short EX+; T1: FSL Backplate elbow EX+; T2: FSL Backplate elbow EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL Backplate elbow DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_ Backplate elbow short EX+:FSL Backplate elbow DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_ Backplate elbow short EX+; Family and Type: FASTLOC_ Backplate elbow short EX+: FSL Backplate elbow DE; Type: FSL Backplate elbow DE; Type Id: 815815
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_ Backplate elbow short EX+:FSL Backplate elbow DE:...) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
861263 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 27.3 | 5.8 | 2.9 | 15 mmø-12 mmø | 0.0000226175 | 22.5 | 12.3 | REHAU Wandwinkel FASTLOC EX+ 16 - Rp 1/2 kurz | 4067936345663 | 13707331001 | 93 | Domestic Cold Water 63
861385 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 27.3 | 5.8 | 2.9 | 15 mmø-12 mmø | 0.0000226175 | 22.5 | 12.3 | REHAU Wandwinkel FASTLOC EX+ 16 - Rp 1/2 kurz | 4067936345663 | 13707331001 | 93 | Domestic Cold Water 64
861445 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.1 | 9.6 | 4.8 | 20 mmø-20 mmø | 0.0000416715 | 26.9 | 11.8 | REHAU Wandwinkel FASTLOC EX+ 25 - Rp 3/4 kurz | 4067936345687 | 13707351001 | 153 | Domestic Cold Water 65
961280 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 27.3 | 5.8 | 2.9 | 15 mmø-12 mmø | 0.0000226175 | 22.5 | 12.3 | REHAU Wandwinkel FASTLOC EX+ 16 - Rp 1/2 kurz | 4067936345663 | 13707331001 | 93 | Domestic Cold Water 159
961282 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 27.3 | 5.8 | 2.9 | 15 mmø-12 mmø | 0.0000226175 | 22.5 | 12.3 | REHAU Wandwinkel FASTLOC EX+ 16 - Rp 1/2 kurz | 4067936345663 | 13707331001 | 93 | Domestic Cold Water 160
961284 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.1 | 9.6 | 4.8 | 20 mmø-20 mmø | 0.0000416715 | 26.9 | 11.8 | REHAU Wandwinkel FASTLOC EX+ 25 - Rp 3/4 kurz | 4067936345687 | 13707351001 | 153 | Domestic Cold Water 161

# IfcFlowFitting: FASTLOC_Adapter coupling EX+:FSL TC EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter coupling EX+; T1: FSL Adapter coupling EX+; T2: FSL Adapter coupling EX+ DN1+2
Type - Constraints - Default Elevation: 13.7 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL TC EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter coupling EX+:FSL TC EX+ AT; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: FASTLOC_Adapter coupling EX+; Family and Type: FASTLOC_Adapter coupling EX+: FSL TC EX+ AT; Type: FSL TC EX+ AT; Type Id: 812008
Constraints - Level: Level 1; Elevation from Level: 13.7 mm
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter coupling EX+:FSL TC EX+ AT:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
907006 | 12 | 9.9 | 7.9 | 12 mmø-12 mmø | 0.0000091357 | 4.3 | 13.7 | REHAU Adapter coupling FASTLOC/RAUTITAN 16 - 16 | 4067936345731 | 13707501001 | 29 | Domestic Cold Water 120
907008 | 15 | 12.5 | 11.5 | 15 mmø-15 mmø | 0.0000161967 | 4.3 | 14.3 | REHAU Adapter coupling FASTLOC/RAUTITAN 20 - 20 | 4067936345748 | 13707511001 | 45 | Domestic Cold Water 118
907010 | 20 | 15.2 | 14.7 | 20 mmø-20 mmø | 0.0000287926 | 4.6 | 16.6 | REHAU Adapter coupling FASTLOC/RAUTITAN 25 - 25 | 4067936345755 | 13707531001 | 84 | Domestic Cold Water 116
907012 | 25 | 19.7 | 19.7 | 25 mmø-25 mmø | 0.0000494063 | 5.5 | 19.3 | REHAU Adapter coupling FASTLOC/RAUTITAN 32 - 32 | 4067936345762 | 13707541001 | 120 | Domestic Cold Water 114
962045 | 12 | 9.9 | 7.9 | 12 mmø-12 mmø | 0.0000091357 | 4.3 | 13.7 | REHAU Adapter coupling FASTLOC/RAUTITAN 16 - 16 | 4067936345731 | 13707501001 | 29 | Domestic Cold Water 254
962047 | 15 | 12.5 | 11.5 | 15 mmø-15 mmø | 0.0000161967 | 4.3 | 14.3 | REHAU Adapter coupling FASTLOC/RAUTITAN 20 - 20 | 4067936345748 | 13707511001 | 45 | Domestic Cold Water 252
962049 | 20 | 15.2 | 14.7 | 20 mmø-20 mmø | 0.0000287926 | 4.6 | 16.6 | REHAU Adapter coupling FASTLOC/RAUTITAN 25 - 25 | 4067936345755 | 13707531001 | 84 | Domestic Cold Water 249
962051 | 25 | 19.7 | 19.7 | 25 mmø-25 mmø | 0.0000494063 | 5.5 | 19.3 | REHAU Adapter coupling FASTLOC/RAUTITAN 32 - 32 | 4067936345762 | 13707541001 | 120 | Domestic Cold Water 245

# IfcFlowFitting: FASTLOC_Adapter coupling EX+:FSL TC EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter coupling EX+; T1: FSL Adapter coupling EX+; T2: FSL Adapter coupling EX+ DN1+2
Type - Constraints - Default Elevation: 13.7 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL TC EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter coupling EX+:FSL TC EX+ DE; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: FASTLOC_Adapter coupling EX+; Family and Type: FASTLOC_Adapter coupling EX+: FSL TC EX+ DE; Type: FSL TC EX+ DE; Type Id: 825705
Constraints - Level: Level 1; Elevation from Level: 13.7 mm
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter coupling EX+:FSL TC EX+ DE:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
869692 | 12 | 9.9 | 7.9 | 12 mmø-12 mmø | 0.0000091357 | 4.3 | 13.7 | REHAU Übergangskupplung FASTLOC/RAUTITAN 16 - 16 | 4067936345731 | 13707501001 | 29 | Domestic Cold Water 8
869893 | 15 | 12.5 | 11.5 | 15 mmø-15 mmø | 0.0000161967 | 4.3 | 14.3 | REHAU Übergangskupplung FASTLOC/RAUTITAN 20 - 20 | 4067936345748 | 13707511001 | 45 | Domestic Cold Water 7
870124 | 20 | 15.2 | 14.7 | 20 mmø-20 mmø | 0.0000287926 | 4.6 | 16.6 | REHAU Übergangskupplung FASTLOC/RAUTITAN 25 - 25 | 4067936345755 | 13707531001 | 84 | Domestic Cold Water 6
870275 | 25 | 19.7 | 19.7 | 25 mmø-25 mmø | 0.0000494063 | 5.5 | 19.3 | REHAU Übergangskupplung FASTLOC/RAUTITAN 32 - 32 | 4067936345762 | 13707541001 | 120 | Domestic Cold Water 5
961299 | 12 | 9.9 | 7.9 | 12 mmø-12 mmø | 0.0000091357 | 4.3 | 13.7 | REHAU Übergangskupplung FASTLOC/RAUTITAN 16 - 16 | 4067936345731 | 13707501001 | 29 | Domestic Cold Water 185
961301 | 15 | 12.5 | 11.5 | 15 mmø-15 mmø | 0.0000161967 | 4.3 | 14.3 | REHAU Übergangskupplung FASTLOC/RAUTITAN 20 - 20 | 4067936345748 | 13707511001 | 45 | Domestic Cold Water 182
