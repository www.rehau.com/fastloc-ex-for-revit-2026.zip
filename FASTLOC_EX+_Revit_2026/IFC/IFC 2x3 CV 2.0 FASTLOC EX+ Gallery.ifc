Properties of the parts of a building model (IFC2X3), part 3 of 6

# IfcFlowFitting: FASTLOC_Adapter coupling EX+:FSL TC EX+ DE (8)
Name (FASTLOC_Adapter coupling EX+:FSL TC EX+ DE:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
961303 | 20 | 15.2 | 14.7 | 20 mmø-20 mmø | 0.0000287926 | 4.6 | 16.6 | REHAU Übergangskupplung FASTLOC/RAUTITAN 25 - 25 | 4067936345755 | 13707531001 | 84 | Domestic Cold Water 179
961305 | 25 | 19.7 | 19.7 | 25 mmø-25 mmø | 0.0000494063 | 5.5 | 19.3 | REHAU Übergangskupplung FASTLOC/RAUTITAN 32 - 32 | 4067936345762 | 13707541001 | 120 | Domestic Cold Water 176

# IfcFlowFitting: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter with union nut EX+; T1: FSL Adapter with union nut EX+; T2: FSL Adapter with union nut EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A union nut EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ AT; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Family: FASTLOC_Adapter with union nut EX+; Family and Type: FASTLOC_Adapter with union nut EX+: FSL A union nut EX+ AT; Type: FSL A union nut EX+ AT; Type Id: 825703
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 60 deg; Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ AT:...) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | L Swievel Nut (mm) | Size = Overall Size | SLW (mm) | SLW*2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906919 | 15 | 20 | 24 | 11.5 | 16.3 | 14.1 | 12.1 | 20 mmø-15 mmø | 15.5 | 31 | 0.0000239972 | 9 | 13 | REHAU Übergang FASTLOC EX+ 20 - G 3/4 | 4067936345427 | 13707161001 | 0.072 | Domestic Cold Water 89
906921 | 20 | 25 | 30.6 | 14.7 | 21 | 15.5 | 12.2 | 25 mmø-20 mmø | 19 | 38 | 0.0000375861 | 10.3 | 11.7 | REHAU Übergang FASTLOC EX+ 25 - G 1 | 4067936345434 | 13707171001 | 0.091 | Domestic Cold Water 90
961960 | 12 | 20 | 24.2 | 7.9 | 12.5 | 14 | 12 | 20 mmø-12 mmø | 15.5 | 31 | 0.0000188575 | 9 | 10 | REHAU Übergang FASTLOC EX+ 16 - G 3/4 | 4067936345410 | 13707151001 | 0.051 | Domestic Cold Water 198
961962 | 15 | 20 | 24 | 11.5 | 16.3 | 14.1 | 12.1 | 20 mmø-15 mmø | 15.5 | 31 | 0.0000239972 | 9 | 13 | REHAU Übergang FASTLOC EX+ 20 - G 3/4 | 4067936345427 | 13707161001 | 0.072 | Domestic Cold Water 200
961964 | 20 | 25 | 30.6 | 14.7 | 21 | 15.5 | 12.2 | 25 mmø-20 mmø | 19 | 38 | 0.0000375861 | 10.3 | 11.7 | REHAU Übergang FASTLOC EX+ 25 - G 1 | 4067936345434 | 13707171001 | 0.091 | Domestic Cold Water 201
961966 | 25 | 32 | 38 | 19.7 | 28.3 | 16.5 | 13.5 | 32 mmø-25 mmø | 23 | 46 | 0.0000635286 | 11.5 | 13.5 | REHAU Übergang FASTLOC EX+ 32 - G 1 1/4 | 4067936345441 | 13707181001 | 0.171 | Domestic Cold Water 203

# IfcFlowFitting: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter with union nut EX+; T1: FSL Adapter with union nut EX+; T2: FSL Adapter with union nut EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A union nut EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ DE; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Family: FASTLOC_Adapter with union nut EX+; Family and Type: FASTLOC_Adapter with union nut EX+: FSL A union nut EX+ DE; Type: FSL A union nut EX+ DE; Type Id: 808058
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Angle: 60 deg; Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ DE:...) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | L Swievel Nut (mm) | Size = Overall Size | SLW (mm) | SLW*2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
835853 | 12 | 20 | 24.2 | 7.9 | 12.5 | 14 | 12 | 20 mmø-12 mmø | 15.5 | 31 | 0.0000188575 | 9 | 10 | REHAU Übergang FASTLOC EX+ 16 - G 3/4 | 4067936345410 | 13707151001 | 0.051 | Domestic Cold Water 41
835865 | 15 | 20 | 24 | 11.5 | 16.3 | 14.1 | 12.1 | 20 mmø-15 mmø | 15.5 | 31 | 0.0000239972 | 9 | 13 | REHAU Übergang FASTLOC EX+ 20 - G 3/4 | 4067936345427 | 13707161001 | 0.072 | Domestic Cold Water 42
835877 | 20 | 25 | 30.6 | 14.7 | 21 | 15.5 | 12.2 | 25 mmø-20 mmø | 19 | 38 | 0.0000375861 | 10.3 | 11.7 | REHAU Übergang FASTLOC EX+ 25 - G 1 | 4067936345434 | 13707171001 | 0.091 | Domestic Cold Water 43
835889 | 25 | 32 | 38 | 19.7 | 28.3 | 16.5 | 13.5 | 32 mmø-25 mmø | 23 | 46 | 0.0000635286 | 11.5 | 13.5 | REHAU Übergang FASTLOC EX+ 32 - G 1 1/4 | 4067936345441 | 13707181001 | 0.171 | Domestic Cold Water 44
906917 | 12 | 20 | 24.2 | 7.9 | 12.5 | 14 | 12 | 20 mmø-12 mmø | 15.5 | 31 | 0.0000188575 | 9 | 10 | REHAU Übergang FASTLOC EX+ 16 - G 3/4 | 4067936345410 | 13707151001 | 0.051 | Domestic Cold Water 88
906923 | 25 | 32 | 38 | 19.7 | 28.3 | 16.5 | 13.5 | 32 mmø-25 mmø | 23 | 46 | 0.0000635286 | 11.5 | 13.5 | REHAU Übergang FASTLOC EX+ 32 - G 1 1/4 | 4067936345441 | 13707181001 | 0.171 | Domestic Cold Water 91
961214 | 12 | 20 | 24.2 | 7.9 | 12.5 | 14 | 12 | 20 mmø-12 mmø | 15.5 | 31 | 0.0000188575 | 9 | 10 | REHAU Übergang FASTLOC EX+ 16 - G 3/4 | 4067936345410 | 13707151001 | 0.051 | Domestic Cold Water 139
961216 | 15 | 20 | 24 | 11.5 | 16.3 | 14.1 | 12.1 | 20 mmø-15 mmø | 15.5 | 31 | 0.0000239972 | 9 | 13 | REHAU Übergang FASTLOC EX+ 20 - G 3/4 | 4067936345427 | 13707161001 | 0.072 | Domestic Cold Water 140
961218 | 20 | 25 | 30.6 | 14.7 | 21 | 15.5 | 12.2 | 25 mmø-20 mmø | 19 | 38 | 0.0000375861 | 10.3 | 11.7 | REHAU Übergang FASTLOC EX+ 25 - G 1 | 4067936345434 | 13707171001 | 0.091 | Domestic Cold Water 142
961220 | 25 | 32 | 38 | 19.7 | 28.3 | 16.5 | 13.5 | 32 mmø-25 mmø | 23 | 46 | 0.0000635286 | 11.5 | 13.5 | REHAU Übergang FASTLOC EX+ 32 - G 1 1/4 | 4067936345441 | 13707181001 | 0.171 | Domestic Cold Water 144

# IfcFlowFitting: FASTLOC_Adapter_EX+, with internal thread:FSL A internal AT (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_EX+, with internal thread; T1: FSL Adapter with internal thread EX+; T2: FSL Adapter with internal thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter_EX+, with internal thread:FSL A internal AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter_EX+, with internal thread; Family and Type: FASTLOC_Adapter_EX+, with internal thread: FSL A internal AT; Type: FSL A internal AT; Type Id: 804796
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_EX+, with internal thread:FSL A internal AT:...) | V1 | V2 | Angle (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906902 | no | yes | 60 | 12 | 15 | 25.5 | 7.9 | 18.6 | 16.2 | 15 mmø-12 mmø | 13.5 | 0.00001366 | 12.4 | 7.3 | REHAU Straight connector FASTLOC EX+ 16 - Rp 1/2 | 4067936345366 | 13706991001 | 63 | Domestic Cold Water 83
906904 | no | yes | 60 | 15 | 15 | 25.5 | 11.5 | 18.7 | 16.2 | 15 mmø-15 mmø | 13.5 | 0.0000189099 | 11.7 | 7.3 | REHAU Straight connector FASTLOC EX+ 20 - Rp 1/2 | 4067936345373 | 13707011001 | 68 | Domestic Cold Water 84
906906 | yes | no | 45 | 15 | 20 | 32 | 11.5 | 24.1 | 17.7 | 20 mmø-15 mmø | 17 | 0.0000233572 | 13.3 | 8.1 | REHAU Straight connector FASTLOC EX+ 20 - Rp 3/4 | 4067936345380 | 13707031001 | 101 | Domestic Cold Water 85
906908 | yes | no | 45 | 20 | 20 | 32 | 14.7 | 24.1 | 17.7 | 20 mmø-20 mmø | 17 | 0.0000325669 | 12.9 | 8.7 | REHAU Straight connector FASTLOC EX+ 25 - Rp 3/4 | 4067936345397 | 13707041001 | 118 | Domestic Cold Water 86
906910 | yes | no | 45 | 25 | 25 | 38.5 | 19.7 | 30.4 | 20.6 | 25 mmø-25 mmø | 20.5 | 0.0000527006 | 14.5 | 8.8 | REHAU Straight connector FASTLOC EX+ 32 - Rp 1 | 4067936345403 | 13707051001 | 192 | Domestic Cold Water 87
961945 | no | yes | 60 | 12 | 15 | 25.5 | 7.9 | 18.6 | 16.2 | 15 mmø-12 mmø | 13.5 | 0.00001366 | 12.4 | 7.3 | REHAU Straight connector FASTLOC EX+ 16 - Rp 1/2 | 4067936345366 | 13706991001 | 63 | Domestic Cold Water 191
961947 | no | yes | 60 | 15 | 15 | 25.5 | 11.5 | 18.7 | 16.2 | 15 mmø-15 mmø | 13.5 | 0.0000189099 | 11.7 | 7.3 | REHAU Straight connector FASTLOC EX+ 20 - Rp 1/2 | 4067936345373 | 13707011001 | 68 | Domestic Cold Water 192
961949 | yes | no | 45 | 15 | 20 | 32 | 11.5 | 24.1 | 17.7 | 20 mmø-15 mmø | 17 | 0.0000233572 | 13.3 | 8.1 | REHAU Straight connector FASTLOC EX+ 20 - Rp 3/4 | 4067936345380 | 13707031001 | 101 | Domestic Cold Water 194
961951 | yes | no | 45 | 20 | 20 | 32 | 14.7 | 24.1 | 17.7 | 20 mmø-20 mmø | 17 | 0.0000325669 | 12.9 | 8.7 | REHAU Straight connector FASTLOC EX+ 25 - Rp 3/4 | 4067936345397 | 13707041001 | 118 | Domestic Cold Water 195
961953 | yes | no | 45 | 25 | 25 | 38.5 | 19.7 | 30.4 | 20.6 | 25 mmø-25 mmø | 20.5 | 0.0000527006 | 14.5 | 8.8 | REHAU Straight connector FASTLOC EX+ 32 - Rp 1 | 4067936345403 | 13707051001 | 192 | Domestic Cold Water 197

# IfcFlowFitting: FASTLOC_Adapter_EX+, with internal thread:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_EX+, with internal thread; T1: FSL Adapter with internal thread EX+; T2: FSL Adapter with internal thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter_EX+, with internal thread:FSL A internal DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter_EX+, with internal thread; Family and Type: FASTLOC_Adapter_EX+, with internal thread: FSL A internal DE; Type: FSL A internal DE; Type Id: 825701
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_EX+, with internal thread:FSL A internal DE:...) | V1 | V2 | Angle (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
830264 | no | yes | 60 | 12 | 15 | 25.5 | 7.9 | 18.6 | 16.2 | 15 mmø-12 mmø | 13.5 | 0.00001366 | 12.4 | 7.3 | REHAU Übergang FASTLOC EX+ 16 - Rp 1/2 | 4067936345366 | 13706991001 | 63 | Domestic Cold Water 36
830276 | no | yes | 60 | 15 | 15 | 25.5 | 11.5 | 18.7 | 16.2 | 15 mmø-15 mmø | 13.5 | 0.0000189099 | 11.7 | 7.3 | REHAU Übergang FASTLOC EX+ 20 - Rp 1/2 | 4067936345373 | 13707011001 | 68 | Domestic Cold Water 37
830288 | yes | no | 45 | 15 | 20 | 32 | 11.5 | 24.1 | 17.7 | 20 mmø-15 mmø | 17 | 0.0000233572 | 13.3 | 8.1 | REHAU Übergang FASTLOC EX+ 20 - Rp 3/4 | 4067936345380 | 13707031001 | 101 | Domestic Cold Water 38
830300 | yes | no | 45 | 20 | 20 | 32 | 14.7 | 24.1 | 17.7 | 20 mmø-20 mmø | 17 | 0.0000325669 | 12.9 | 8.7 | REHAU Übergang FASTLOC EX+ 25 - Rp 3/4 | 4067936345397 | 13707041001 | 118 | Domestic Cold Water 39
830312 | yes | no | 45 | 25 | 25 | 38.5 | 19.7 | 30.4 | 20.6 | 25 mmø-25 mmø | 20.5 | 0.0000527006 | 14.5 | 8.8 | REHAU Übergang FASTLOC EX+ 32 - Rp 1 | 4067936345403 | 13707051001 | 192 | Domestic Cold Water 40
961199 | no | yes | 60 | 12 | 15 | 25.5 | 7.9 | 18.6 | 16.2 | 15 mmø-12 mmø | 13.5 | 0.00001366 | 12.4 | 7.3 | REHAU Übergang FASTLOC EX+ 16 - Rp 1/2 | 4067936345366 | 13706991001 | 63 | Domestic Cold Water 127
961201 | no | yes | 60 | 15 | 15 | 25.5 | 11.5 | 18.7 | 16.2 | 15 mmø-15 mmø | 13.5 | 0.0000189099 | 11.7 | 7.3 | REHAU Übergang FASTLOC EX+ 20 - Rp 1/2 | 4067936345373 | 13707011001 | 68 | Domestic Cold Water 128
961203 | yes | no | 45 | 15 | 20 | 32 | 11.5 | 24.1 | 17.7 | 20 mmø-15 mmø | 17 | 0.0000233572 | 13.3 | 8.1 | REHAU Übergang FASTLOC EX+ 20 - Rp 3/4 | 4067936345380 | 13707031001 | 101 | Domestic Cold Water 129
961205 | yes | no | 45 | 20 | 20 | 32 | 14.7 | 24.1 | 17.7 | 20 mmø-20 mmø | 17 | 0.0000325669 | 12.9 | 8.7 | REHAU Übergang FASTLOC EX+ 25 - Rp 3/4 | 4067936345397 | 13707041001 | 118 | Domestic Cold Water 130
961207 | yes | no | 45 | 25 | 25 | 38.5 | 19.7 | 30.4 | 20.6 | 25 mmø-25 mmø | 20.5 | 0.0000527006 | 14.5 | 8.8 | REHAU Übergang FASTLOC EX+ 32 - Rp 1 | 4067936345403 | 13707051001 | 192 | Domestic Cold Water 136

# IfcFlowFitting: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ AT (14)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_RX+, with external thread; T1: FSL Adapter coupling external thread EX+; T2: FSL Adapter coupling external thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A C external EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter_RX+, with external thread; Family and Type: FASTLOC_Adapter_RX+, with external thread: FSL A C external EX+ AT; Type: FSL A C external EX+ AT; Type Id: 825699
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ AT:...) | A (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906888 | 60 | 12 | 15 | 7.9 | 15 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000135744 | 8.9 | 7.8 | REHAU Straight connector FASTLOC RX+ 16 - R 1/2 | 4067936345298 | 13706881001 | 45 | Domestic Cold Water 76
906890 | 45 | 12 | 20 | 7.9 | 19 | 20 mmø-12 mmø | 23 | 11.5 | 0.0000157567 | 8.9 | 12.9 | REHAU Straight connector FASTLOC RX+ 16 - R 3/4 | 4067936345304 | 13706891001 | 52 | Domestic Cold Water 77
906892 | 60 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000196278 | 8.7 | 8.4 | REHAU Straight connector FASTLOC RX+ 20 - R 1/2 | 4067936345311 | 13706911001 | 52 | Domestic Cold Water 78
906894 | 45 | 15 | 20 | 11.5 | 19 | 20 mmø-15 mmø | 23 | 11.5 | 0.0000213148 | 9.3 | 12.5 | REHAU Straight connector FASTLOC RX+ 20 - R 3/4 | 4067936345328 | 13706941001 | 75 | Domestic Cold Water 79
906896 | 45 | 20 | 20 | 14.7 | 19 | 20 mmø-20 mmø | 23 | 11.5 | 0.0000308839 | 9.4 | 12.9 | REHAU Straight connector FASTLOC RX+ 25 - R 3/4 | 4067936345335 | 13706951001 | 94 | Domestic Cold Water 80
906898 | 45 | 20 | 25 | 14.7 | 25.5 | 25 mmø-20 mmø | 36 | 18 | 0.0000362254 | 9.4 | 8.7 | REHAU Straight connector FASTLOC RX+ 25 - R 1 | 4067936345342 | 13706961001 | 94 | Domestic Cold Water 81
906900 | 45 | 25 | 25 | 19.7 | 24 | 25 mmø-25 mmø | 36 | 18 | 0.0000529587 | 14.6 | 8.7 | REHAU Straight connector FASTLOC RX+ 32 - R 1 | 4067936345359 | 13706981001 | 182 | Domestic Cold Water 82
961931 | 60 | 12 | 15 | 7.9 | 15 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000135744 | 8.9 | 7.8 | REHAU Straight connector FASTLOC RX+ 16 - R 1/2 | 4067936345298 | 13706881001 | 45 | Domestic Cold Water 175
961933 | 45 | 12 | 20 | 7.9 | 19 | 20 mmø-12 mmø | 23 | 11.5 | 0.0000157567 | 8.9 | 12.9 | REHAU Straight connector FASTLOC RX+ 16 - R 3/4 | 4067936345304 | 13706891001 | 52 | Domestic Cold Water 177
961935 | 60 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000196278 | 8.7 | 8.4 | REHAU Straight connector FASTLOC RX+ 20 - R 1/2 | 4067936345311 | 13706911001 | 52 | Domestic Cold Water 180
961937 | 45 | 15 | 20 | 11.5 | 19 | 20 mmø-15 mmø | 23 | 11.5 | 0.0000213148 | 9.3 | 12.5 | REHAU Straight connector FASTLOC RX+ 20 - R 3/4 | 4067936345328 | 13706941001 | 75 | Domestic Cold Water 183
961939 | 45 | 20 | 20 | 14.7 | 19 | 20 mmø-20 mmø | 23 | 11.5 | 0.0000308839 | 9.4 | 12.9 | REHAU Straight connector FASTLOC RX+ 25 - R 3/4 | 4067936345335 | 13706951001 | 94 | Domestic Cold Water 186
961941 | 45 | 20 | 25 | 14.7 | 25.5 | 25 mmø-20 mmø | 36 | 18 | 0.0000362254 | 9.4 | 8.7 | REHAU Straight connector FASTLOC RX+ 25 - R 1 | 4067936345342 | 13706961001 | 94 | Domestic Cold Water 188
961943 | 45 | 25 | 25 | 19.7 | 24 | 25 mmø-25 mmø | 36 | 18 | 0.0000529587 | 14.6 | 8.7 | REHAU Straight connector FASTLOC RX+ 32 - R 1 | 4067936345359 | 13706981001 | 182 | Domestic Cold Water 189

# IfcFlowFitting: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ DE (14)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Adapter_RX+, with external thread; T1: FSL Adapter coupling external thread EX+; T2: FSL Adapter coupling external thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A C external EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Adapter_RX+, with external thread; Family and Type: FASTLOC_Adapter_RX+, with external thread: FSL A C external EX+ DE; Type: FSL A C external EX+ DE; Type Id: 802296
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ DE:...) | A (deg) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
829096 | 60 | 12 | 15 | 7.9 | 15 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000135744 | 8.9 | 7.8 | REHAU Übergang FASTLOC RX+ 16 - R 1/2 | 4067936345298 | 13706881001 | 45 | Domestic Cold Water 29
829108 | 45 | 12 | 20 | 7.9 | 19 | 20 mmø-12 mmø | 23 | 11.5 | 0.0000157567 | 8.9 | 12.9 | REHAU Übergang FASTLOC RX+ 16 - R 3/4 | 4067936345304 | 13706891001 | 52 | Domestic Cold Water 30
829120 | 60 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000196278 | 8.7 | 8.4 | REHAU Übergang FASTLOC RX+ 20 - R 1/2 | 4067936345311 | 13706911001 | 52 | Domestic Cold Water 31
829132 | 45 | 15 | 20 | 11.5 | 19 | 20 mmø-15 mmø | 23 | 11.5 | 0.0000213148 | 9.3 | 12.5 | REHAU Übergang FASTLOC RX+ 20 - R 3/4 | 4067936345328 | 13706941001 | 75 | Domestic Cold Water 32
829144 | 45 | 20 | 20 | 14.7 | 19 | 20 mmø-20 mmø | 23 | 11.5 | 0.0000308839 | 9.4 | 12.9 | REHAU Übergang FASTLOC RX+ 25 - R 3/4 | 4067936345335 | 13706951001 | 94 | Domestic Cold Water 33
829156 | 45 | 20 | 25 | 14.7 | 25.5 | 25 mmø-20 mmø | 36 | 18 | 0.0000362254 | 9.4 | 8.7 | REHAU Übergang FASTLOC RX+ 25 - R 1 | 4067936345342 | 13706961001 | 94 | Domestic Cold Water 34
829168 | 45 | 25 | 25 | 19.7 | 24 | 25 mmø-25 mmø | 36 | 18 | 0.0000529587 | 14.6 | 8.7 | REHAU Übergang FASTLOC RX+ 32 - R 1 | 4067936345359 | 13706981001 | 182 | Domestic Cold Water 35
961185 | 60 | 12 | 15 | 7.9 | 15 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000135744 | 8.9 | 7.8 | REHAU Übergang FASTLOC RX+ 16 - R 1/2 | 4067936345298 | 13706881001 | 45 | Domestic Cold Water 119
961187 | 45 | 12 | 20 | 7.9 | 19 | 20 mmø-12 mmø | 23 | 11.5 | 0.0000157567 | 8.9 | 12.9 | REHAU Übergang FASTLOC RX+ 16 - R 3/4 | 4067936345304 | 13706891001 | 52 | Domestic Cold Water 121
961189 | 60 | 15 | 15 | 11.5 | 15 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000196278 | 8.7 | 8.4 | REHAU Übergang FASTLOC RX+ 20 - R 1/2 | 4067936345311 | 13706911001 | 52 | Domestic Cold Water 122
961191 | 45 | 15 | 20 | 11.5 | 19 | 20 mmø-15 mmø | 23 | 11.5 | 0.0000213148 | 9.3 | 12.5 | REHAU Übergang FASTLOC RX+ 20 - R 3/4 | 4067936345328 | 13706941001 | 75 | Domestic Cold Water 123
961193 | 45 | 20 | 20 | 14.7 | 19 | 20 mmø-20 mmø | 23 | 11.5 | 0.0000308839 | 9.4 | 12.9 | REHAU Übergang FASTLOC RX+ 25 - R 3/4 | 4067936345335 | 13706951001 | 94 | Domestic Cold Water 124
961195 | 45 | 20 | 25 | 14.7 | 25.5 | 25 mmø-20 mmø | 36 | 18 | 0.0000362254 | 9.4 | 8.7 | REHAU Übergang FASTLOC RX+ 25 - R 1 | 4067936345342 | 13706961001 | 94 | Domestic Cold Water 125
961197 | 45 | 25 | 25 | 19.7 | 24 | 25 mmø-25 mmø | 36 | 18 | 0.0000529587 | 14.6 | 8.7 | REHAU Übergang FASTLOC RX+ 32 - R 1 | 4067936345359 | 13706981001 | 182 | Domestic Cold Water 126

# IfcFlowFitting: FASTLOC_Blanking plug EX+:FSL Bp EX+ AT (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Blanking plug EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL Bp EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Blanking plug EX+:FSL Bp EX+ AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Blanking plug EX+; Family and Type: FASTLOC_Blanking plug EX+: FSL Bp EX+ AT; Type: FSL Bp EX+ AT; Type Id: 799403
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Z1: 6.7 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Blanking plug EX+:FSL Bp EX+ AT:...) | Area (m2) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight | System Name = Group
907000 | 0.00717277 | 12 | 7.9 | 12 mmø | 0.00000542763 | REHAU Blanking plug FASTLOC EX+ 16 | 4067936345717 | 13707381001 | 14 | Domestic Cold Water 104
907002 | 0.00880737 | 15 | 11.5 | 15 mmø | 0.0000102781 | REHAU Blanking plug FASTLOC EX+ 20 | 4067936345724 | 13707391001 | 23 | Domestic Cold Water 105
962039 | 0.00717277 | 12 | 7.9 | 12 mmø | 0.00000542763 | REHAU Blanking plug FASTLOC EX+ 16 | 4067936345717 | 13707381001 | 14 | Domestic Cold Water 234
962041 | 0.00880737 | 15 | 11.5 | 15 mmø | 0.0000102781 | REHAU Blanking plug FASTLOC EX+ 20 | 4067936345724 | 13707391001 | 23 | Domestic Cold Water 235

# IfcFlowFitting: FASTLOC_Blanking plug EX+:FSL Bp EX+ DE (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Blanking plug EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL Bp EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Blanking plug EX+:FSL Bp EX+ DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Blanking plug EX+; Family and Type: FASTLOC_Blanking plug EX+: FSL Bp EX+ DE; Type: FSL Bp EX+ DE; Type Id: 825697
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Z1: 6.7 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Blanking plug EX+:FSL Bp EX+ DE:...) | Area (m2) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight | System Name = Group
869389 | 0.00717277 | 12 | 7.9 | 12 mmø | 0.00000542763 | REHAU Blindstopfen FASTLOC EX+ 16 | 4067936345717 | 13707381001 | 14 | Domestic Cold Water 66
869442 | 0.00880737 | 15 | 11.5 | 15 mmø | 0.0000102781 | REHAU Blindstopfen FASTLOC EX+ 20 | 4067936345724 | 13707391001 | 23 | Domestic Cold Water 67
961293 | 0.00717277 | 12 | 7.9 | 12 mmø | 0.00000542763 | REHAU Blindstopfen FASTLOC EX+ 16 | 4067936345717 | 13707381001 | 14 | Domestic Cold Water 162
961295 | 0.00880737 | 15 | 11.5 | 15 mmø | 0.0000102781 | REHAU Blindstopfen FASTLOC EX+ 20 | 4067936345724 | 13707391001 | 23 | Domestic Cold Water 163

# IfcFlowFitting: FASTLOC_Corner EX+:FSL C EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Corner EX+; T1: FSL Corner EX+; T2: FSL Corner DN1+2 EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Corner EX+:FSL C EX+ AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Corner EX+; Family and Type: FASTLOC_Corner EX+: FSL C EX+ AT; Type: FSL C EX+ AT; Type Id: 795831
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Corner EX+:FSL C EX+ AT:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906941 | 12 | 7.9 | 8 | 4 | 12 mmø-12 mmø | 0.0000155943 | 22.1 | REHAU Elbow FASTLOC EX+ 16 - 16, 90 degree | 4067936345496 | 13707081001 | 40 | Domestic Cold Water 137
906943 | 15 | 11.5 | 10 | 5 | 15 mmø-15 mmø | 0.0000283876 | 24.6 | REHAU Elbow FASTLOC EX+ 20 - 20, 90 degree | 4067936345502 | 13707091001 | 64 | Domestic Cold Water 138
906945 | 20 | 14.7 | 12.5 | 6.25 | 20 mmø-20 mmø | 0.0000496795 | 29 | REHAU Elbow FASTLOC EX+ 25 - 25, 90 degree | 4067936345519 | 13707111001 | 118 | Domestic Cold Water 141
906947 | 25 | 19.7 | 16 | 8 | 25 mmø-25 mmø | 0.0000852828 | 35 | REHAU Elbow FASTLOC EX+ 32 - 32, 90 degree | 4067936345526 | 13707141001 | 219 | Domestic Cold Water 143
961984 | 12 | 7.9 | 8 | 4 | 12 mmø-12 mmø | 0.0000155943 | 22.1 | REHAU Elbow FASTLOC EX+ 16 - 16, 90 degree | 4067936345496 | 13707081001 | 40 | Domestic Cold Water 278
961986 | 15 | 11.5 | 10 | 5 | 15 mmø-15 mmø | 0.0000283876 | 24.6 | REHAU Elbow FASTLOC EX+ 20 - 20, 90 degree | 4067936345502 | 13707091001 | 64 | Domestic Cold Water 280
961988 | 20 | 14.7 | 12.5 | 6.25 | 20 mmø-20 mmø | 0.0000496795 | 29 | REHAU Elbow FASTLOC EX+ 25 - 25, 90 degree | 4067936345519 | 13707111001 | 118 | Domestic Cold Water 284
961990 | 25 | 19.7 | 16 | 8 | 25 mmø-25 mmø | 0.0000852828 | 35 | REHAU Elbow FASTLOC EX+ 32 - 32, 90 degree | 4067936345526 | 13707141001 | 219 | Domestic Cold Water 287

# IfcFlowFitting: FASTLOC_Corner EX+:FSL C EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Corner EX+; T1: FSL Corner EX+; T2: FSL Corner DN1+2 EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Corner EX+:FSL C EX+ DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Corner EX+; Family and Type: FASTLOC_Corner EX+: FSL C EX+ DE; Type: FSL C EX+ DE; Type Id: 825695
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Corner EX+:FSL C EX+ DE:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
840610 | 12 | 7.9 | 8 | 4 | 12 mmø-12 mmø | 0.0000155943 | 22.1 | REHAU Winkel FASTLOC EX+ 16 - 16, 90 Grad | 4067936345496 | 13707081001 | 40 | Domestic Cold Water 15
840858 | 15 | 11.5 | 10 | 5 | 15 mmø-15 mmø | 0.0000283876 | 24.6 | REHAU Winkel FASTLOC EX+ 20 - 20, 90 Grad | 4067936345502 | 13707091001 | 64 | Domestic Cold Water 17
841038 | 20 | 14.7 | 12.5 | 6.25 | 20 mmø-20 mmø | 0.0000496795 | 29 | REHAU Winkel FASTLOC EX+ 25 - 25, 90 Grad | 4067936345519 | 13707111001 | 118 | Domestic Cold Water 18
841140 | 25 | 19.7 | 16 | 8 | 25 mmø-25 mmø | 0.0000852828 | 35 | REHAU Winkel FASTLOC EX+ 32 - 32, 90 Grad | 4067936345526 | 13707141001 | 219 | Domestic Cold Water 20
961238 | 12 | 7.9 | 8 | 4 | 12 mmø-12 mmø | 0.0000155943 | 22.1 | REHAU Winkel FASTLOC EX+ 16 - 16, 90 Grad | 4067936345496 | 13707081001 | 40 | Domestic Cold Water 210
961240 | 15 | 11.5 | 10 | 5 | 15 mmø-15 mmø | 0.0000283876 | 24.6 | REHAU Winkel FASTLOC EX+ 20 - 20, 90 Grad | 4067936345502 | 13707091001 | 64 | Domestic Cold Water 212
961242 | 20 | 14.7 | 12.5 | 6.25 | 20 mmø-20 mmø | 0.0000496795 | 29 | REHAU Winkel FASTLOC EX+ 25 - 25, 90 Grad | 4067936345519 | 13707111001 | 118 | Domestic Cold Water 216
961244 | 25 | 19.7 | 16 | 8 | 25 mmø-25 mmø | 0.0000852828 | 35 | REHAU Winkel FASTLOC EX+ 32 - 32, 90 Grad | 4067936345526 | 13707141001 | 219 | Domestic Cold Water 219

# IfcFlowFitting: FASTLOC_Coupling equal EX+:FSL C EQ EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling equal EX+; T1: FSL Coupling EX+ EQ; T2: FSL Coupling EX+ DN1+2 EQ
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C EQ EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Coupling equal EX+:FSL C EQ EX+ AT; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: FASTLOC_Coupling equal EX+; Family and Type: FASTLOC_Coupling equal EX+: FSL C EQ EX+ AT; Type: FSL C EQ EX+ AT; Type Id: 1011625
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling equal EX+:FSL C EQ EX+ AT:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906867 | 12 | 7.9 | 12 mmø-12 mmø | 0.0000136639 | 7.2 | REHAU Kupplung FASTLOC EX+ 16 - 16 | 4067936345229 | 13706791001 | 29 | Domestic Cold Water 164
906869 | 15 | 11.5 | 15 mmø-15 mmø | 0.0000250089 | 7.4 | REHAU Kupplung FASTLOC EX+ 20 - 20 | 4067936345236 | 13706811001 | 45 | Domestic Cold Water 166
906871 | 20 | 14.7 | 20 mmø-20 mmø | 0.0000437837 | 8 | REHAU Kupplung FASTLOC EX+ 25 - 25 | 4067936345243 | 13706831001 | 84 | Domestic Cold Water 168
906873 | 25 | 19.7 | 25 mmø-25 mmø | 0.0000738583 | 10 | REHAU Kupplung FASTLOC EX+ 32 - 32 | 4067936345250 | 13706841001 | 159 | Domestic Cold Water 170
961910 | 12 | 7.9 | 12 mmø-12 mmø | 0.0000136639 | 7.2 | REHAU Kupplung FASTLOC EX+ 16 - 16 | 4067936345229 | 13706791001 | 29 | Domestic Cold Water 316
961912 | 15 | 11.5 | 15 mmø-15 mmø | 0.0000250089 | 7.4 | REHAU Kupplung FASTLOC EX+ 20 - 20 | 4067936345236 | 13706811001 | 45 | Domestic Cold Water 318
961914 | 20 | 14.7 | 20 mmø-20 mmø | 0.0000437837 | 8 | REHAU Kupplung FASTLOC EX+ 25 - 25 | 4067936345243 | 13706831001 | 84 | Domestic Cold Water 320
961916 | 25 | 19.7 | 25 mmø-25 mmø | 0.0000738583 | 10 | REHAU Kupplung FASTLOC EX+ 32 - 32 | 4067936345250 | 13706841001 | 159 | Domestic Cold Water 322

# IfcFlowFitting: FASTLOC_Coupling equal EX+:FSL C EQ EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling equal EX+; T1: FSL Coupling EX+ EQ; T2: FSL Coupling EX+ DN1+2 EQ
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C EQ EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Coupling equal EX+:FSL C EQ EX+ DE; sets with these values: 2
Other - IsCustom: no; V1: yes; V2: no; Family: FASTLOC_Coupling equal EX+; Family and Type: FASTLOC_Coupling equal EX+: FSL C EQ EX+ DE; Type: FSL C EQ EX+ DE; Type Id: 1011623
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling equal EX+:FSL C EQ EX+ DE:...) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) = ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
827927 | 12 | 7.9 | 12 mmø-12 mmø | 0.0000136639 | 7.2 | REHAU Kupplung FASTLOC EX+ 16 - 16 | 4067936345229 | 13706791001 | 29 | Domestic Cold Water 21
827939 | 15 | 11.5 | 15 mmø-15 mmø | 0.0000250089 | 7.4 | REHAU Kupplung FASTLOC EX+ 20 - 20 | 4067936345236 | 13706811001 | 45 | Domestic Cold Water 22
827951 | 20 | 14.7 | 20 mmø-20 mmø | 0.0000437837 | 8 | REHAU Kupplung FASTLOC EX+ 25 - 25 | 4067936345243 | 13706831001 | 84 | Domestic Cold Water 23
827967 | 25 | 19.7 | 25 mmø-25 mmø | 0.0000738583 | 10 | REHAU Kupplung FASTLOC EX+ 32 - 32 | 4067936345250 | 13706841001 | 159 | Domestic Cold Water 24
961164 | 12 | 7.9 | 12 mmø-12 mmø | 0.0000136639 | 7.2 | REHAU Kupplung FASTLOC EX+ 16 - 16 | 4067936345229 | 13706791001 | 29 | Domestic Cold Water 244
961166 | 15 | 11.5 | 15 mmø-15 mmø | 0.0000250089 | 7.4 | REHAU Kupplung FASTLOC EX+ 20 - 20 | 4067936345236 | 13706811001 | 45 | Domestic Cold Water 246
961168 | 20 | 14.7 | 20 mmø-20 mmø | 0.0000437837 | 8 | REHAU Kupplung FASTLOC EX+ 25 - 25 | 4067936345243 | 13706831001 | 84 | Domestic Cold Water 248
961170 | 25 | 19.7 | 25 mmø-25 mmø | 0.0000738583 | 10 | REHAU Kupplung FASTLOC EX+ 32 - 32 | 4067936345250 | 13706841001 | 159 | Domestic Cold Water 250

# IfcFlowFitting: FASTLOC_Coupling reduced EX+:FSL C RE EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling reduced EX+; T1: FSL Coupling EX+ RE; T2: FSL Coupling EX+ DN1+2 RE
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C RE EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Coupling reduced EX+:FSL C RE EX+ AT; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Family: FASTLOC_Coupling reduced EX+; Family and Type: FASTLOC_Coupling reduced EX+: FSL C RE EX+ AT; Type: FSL C RE EX+ AT; Type Id: 1037840
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling reduced EX+:FSL C RE EX+ AT:...) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906875 | 15 | 12 | 11.5 | 7.9 | 15 mmø-12 mmø | 0.0000195319 | 8.7 | 6.3 | REHAU Kupplung FASTLOC EX+ 20 - 16 | 4067936345267 | 13706851001 | 37 | Domestic Cold Water 107
906877 | 20 | 15 | 14.7 | 11.5 | 20 mmø-15 mmø | 0.0000347107 | 9.8 | 5.7 | REHAU Kupplung FASTLOC EX+ 25 - 20 | 4067936345274 | 13706861001 | 64 | Domestic Cold Water 109
906879 | 25 | 20 | 19.7 | 14.7 | 25 mmø-20 mmø | 0.0000596766 | 12.4 | 5.8 | REHAU Kupplung FASTLOC EX+ 32 - 25 | 4067936345281 | 13706871001 | 120 | Domestic Cold Water 111
961918 | 15 | 12 | 11.5 | 7.9 | 15 mmø-12 mmø | 0.0000195319 | 8.7 | 6.3 | REHAU Kupplung FASTLOC EX+ 20 - 16 | 4067936345267 | 13706851001 | 37 | Domestic Cold Water 385
961920 | 20 | 15 | 14.7 | 11.5 | 20 mmø-15 mmø | 0.0000347107 | 9.8 | 5.7 | REHAU Kupplung FASTLOC EX+ 25 - 20 | 4067936345274 | 13706861001 | 64 | Domestic Cold Water 387
961922 | 25 | 20 | 19.7 | 14.7 | 25 mmø-20 mmø | 0.0000596766 | 12.4 | 5.8 | REHAU Kupplung FASTLOC EX+ 32 - 25 | 4067936345281 | 13706871001 | 120 | Domestic Cold Water 389

# IfcFlowFitting: FASTLOC_Coupling reduced EX+:FSL C RE EX+ DE (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Coupling reduced EX+; T1: FSL Coupling EX+ RE; T2: FSL Coupling EX+ DN1+2 RE
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL C RE EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Coupling reduced EX+:FSL C RE EX+ DE; sets with these values: 2
Other - IsCustom: no; V1: no; V2: yes; Family: FASTLOC_Coupling reduced EX+; Family and Type: FASTLOC_Coupling reduced EX+: FSL C RE EX+ DE; Type: FSL C RE EX+ DE; Type Id: 1037838
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Coupling reduced EX+:FSL C RE EX+ DE:...) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
828696 | 15 | 12 | 11.5 | 7.9 | 15 mmø-12 mmø | 0.0000195319 | 8.7 | 6.3 | REHAU Kupplung FASTLOC EX+ 20 - 16 | 4067936345267 | 13706851001 | 37 | Domestic Cold Water 237
828708 | 20 | 15 | 14.7 | 11.5 | 20 mmø-15 mmø | 0.0000347107 | 9.8 | 5.7 | REHAU Kupplung FASTLOC EX+ 25 - 20 | 4067936345274 | 13706861001 | 64 | Domestic Cold Water 239
828720 | 25 | 20 | 19.7 | 14.7 | 25 mmø-20 mmø | 0.0000596766 | 12.4 | 5.8 | REHAU Kupplung FASTLOC EX+ 32 - 25 | 4067936345281 | 13706871001 | 120 | Domestic Cold Water 241
961172 | 15 | 12 | 11.5 | 7.9 | 15 mmø-12 mmø | 0.0000195319 | 8.7 | 6.3 | REHAU Kupplung FASTLOC EX+ 20 - 16 | 4067936345267 | 13706851001 | 37 | Domestic Cold Water 243
961174 | 20 | 15 | 14.7 | 11.5 | 20 mmø-15 mmø | 0.0000347107 | 9.8 | 5.7 | REHAU Kupplung FASTLOC EX+ 25 - 20 | 4067936345274 | 13706861001 | 64 | Domestic Cold Water 247
961176 | 25 | 20 | 19.7 | 14.7 | 25 mmø-20 mmø | 0.0000596766 | 12.4 | 5.8 | REHAU Kupplung FASTLOC EX+ 32 - 25 | 4067936345281 | 13706871001 | 120 | Domestic Cold Water 251

# IfcFlowFitting: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Double-wall-mounted elbow EX+, with internal thread; T1: FSL Double wall mounted Elbow EX+; T2: FSL Double wall mounted Elbow EX+DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - ETIM Class code: EC003025; Manufacturer: REHAU; REHAU Info: 2025.02.27-419114-419114; Type Name: FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT; sets with these values: 2
Other - Family: FASTLOC_Double-wall-mounted elbow EX+, with internal thread; Family and Type: FASTLOC_Double-wall-mounted elbow EX+, with internal thread: FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT; Type: FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT; Type Id: 824408
Constraints - Elevation from Level: 0 mm; Level: Level 1
Construction - REH_LONG: no; Nominal Diameter 2: 15 mm
Data - PID Check: 1 mm
Dimensions - a: 44 deg; n: 5; D: 57.6 mm; DN2: 15 mm; Do2: 15 mm; Le1: 57 mm; Le2: 50 mm; Maximum Size: 15 mm; r: 20 mm; t1: 2.7 mm; t2: 2.7 mm
Graphics - Use Annotation Scale: no
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
