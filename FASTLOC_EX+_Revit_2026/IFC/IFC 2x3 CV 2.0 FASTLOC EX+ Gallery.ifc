Properties of the parts of a building model (IFC2X3), part 5 of 6

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML AT bar (134)
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: FASTLOC EX+; Type Comments: DN 12-32; Type Name: FASTLOC EX+ ML AT bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:FASTLOC EX+ ML AT bar; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: FASTLOC EX+ ML AT bar; Type: FASTLOC EX+ ML AT bar; Type Id: 378045
Constraints - Horizontal Justification: Center; Reference Level: Level 1; Slope: 0; Vertical Justification: Middle
Mechanical - System Type: Domestic Cold Water; Material: FASTLOC EX+ ML bar; Pipe Segment: FASTLOC EX+ ML bar - 12 - 32; Schedule/Type: 12 - 32; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa; Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:FASTLOC EX+ ML AT bar:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) = Dimensions, Length (mm) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | End Middle Elevation (mm) = Lower End Centerline Elevation (mm) = Middle Elevation (mm) = Start Middle Elevation (mm) = Upper End Centerline Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Section | Relative Roughness
888223 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 72 | 2 | 0.000583333
907026 | 160 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00603186 | 12 | Domestic Cold Water 106 | 1 | 0.000583333
907028 | 192 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00723823 | 12 | Domestic Cold Water 106 | 1 | 0.000583333
907032 | 180 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0084823 | 15 | Domestic Cold Water 108 | 1 | 0.0004375
907034 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 108 | 1 | 0.0004375
907038 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 110 | 1 | 0.00035
907040 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 110 | 1 | 0.00035
907044 | 200 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.015708 | 25 | Domestic Cold Water 112 | 1 | 0.000269231
907046 | 184 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0144513 | 25 | Domestic Cold Water 112 | 1 | 0.000269231
907050 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 114 | 1 | 0.000269231
907052 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 114 | 2 | 0.000269231
907054 | 240 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 116 | 2 | 0.00035
907056 | 182.7 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0114794 | 20 | Domestic Cold Water 116 | 1 | 0.00035
907058 | 120 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.00565487 | 15 | Domestic Cold Water 118 | 1 | 0.0004375
907060 | 240.3 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.0113239 | 15 | Domestic Cold Water 118 | 2 | 0.0004375
907062 | 120.6 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00454651 | 12 | Domestic Cold Water 120 | 1 | 0.000583333
907064 | 200 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00753982 | 12 | Domestic Cold Water 120 | 2 | 0.000583333
907066 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 104 | 1 | 0.000583333
907068 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 105 | 1 | 0.0004375
907070 | 130.2 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00490842 | 12 | Domestic Cold Water 101 | 3 | 0.000583333
907072 | 190.2 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00717037 | 12 | Domestic Cold Water 102 | 3 | 0.000583333
907074 | 199.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125601 | 20 | Domestic Cold Water 103 | 1 | 0.00035
907076 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 99 | 1 | 0.00035
907078 | 221 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0104144 | 15 | Domestic Cold Water 98 | 3 | 0.0004375
907080 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 97 | 1 | 0.0004375
907082 | 240.4 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00906287 | 12 | Domestic Cold Water 96 | 3 | 0.000583333
907084 | 220 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0082938 | 12 | Domestic Cold Water 131 | 1 | 0.000583333
907086 | 219.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103484 | 15 | Domestic Cold Water 132 | 1 | 0.0004375
907088 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 133 | 1 | 0.0004375
907090 | 250 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.015708 | 20 | Domestic Cold Water 134 | 1 | 0.00035
907092 | 230 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0180642 | 25 | Domestic Cold Water 135 | 1 | 0.000269231
907094 | 280 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0219911 | 25 | Domestic Cold Water 100 | 1 | 0.000269231
907096 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 137 | 1 | 0.000583333
907098 | 237.5 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0111919 | 15 | Domestic Cold Water 138 | 1 | 0.0004375
907100 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 138 | 1 | 0.0004375
907102 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 137 | 1 | 0.000583333
907104 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 141 | 1 | 0.00035
907106 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 141 | 1 | 0.00035
907108 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 143 | 1 | 0.000269231
907110 | 227.1 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0178364 | 25 | Domestic Cold Water 143 | 1 | 0.000269231
907112 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 95 | 3 | 0.000269231
907114 | 202.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0127235 | 20 | Domestic Cold Water 94 | 3 | 0.00035
907116 | 223.9 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.010551 | 15 | Domestic Cold Water 93 | 3 | 0.0004375
907118 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 92 | 3 | 0.000583333
907120 | 150 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00565487 | 12 | Domestic Cold Water 88 | 3 | 0.000583333
907122 | 150 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00706858 | 15 | Domestic Cold Water 89 | 3 | 0.0004375
907124 | 148.7 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0093431 | 20 | Domestic Cold Water 90 | 1 | 0.00035
907126 | 147.5 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0115846 | 25 | Domestic Cold Water 91 | 1 | 0.000269231
907128 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 83 | 3 | 0.000583333
907130 | 180.7 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00851529 | 15 | Domestic Cold Water 84 | 2 | 0.0004375
907132 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 85 | 3 | 0.0004375
907134 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 86 | 2 | 0.00035
907136 | 218.4 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0171531 | 25 | Domestic Cold Water 87 | 2 | 0.000269231
907138 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 81 | 5 | 0.00035
907140 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 80 | 4 | 0.00035
907142 | 162.373 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00765165 | 15 | Domestic Cold Water 79 | 4 | 0.0004375
907144 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 78 | 3 | 0.0004375
907146 | 209.67 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00790439 | 12 | Domestic Cold Water 77 | 4 | 0.000583333
907148 | 174.217 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00656781 | 12 | Domestic Cold Water 76 | 4 | 0.000583333
907150 | 140 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00527788 | 12 | Domestic Cold Water 164 | 1 | 0.000583333
907152 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 164 | 1 | 0.000583333
907154 | 160 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00753982 | 15 | Domestic Cold Water 166 | 1 | 0.0004375
907156 | 179.8 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00847288 | 15 | Domestic Cold Water 166 | 1 | 0.0004375
907158 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 168 | 1 | 0.00035
907160 | 160 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0100531 | 20 | Domestic Cold Water 168 | 1 | 0.00035
907162 | 178 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0139801 | 25 | Domestic Cold Water 170 | 1 | 0.000269231
907164 | 180 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 170 | 1 | 0.000269231
907166 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 75 | 4 | 0.00035
907168 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 75 | 5 | 0.00035
907170 | 135 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00636173 | 15 | Domestic Cold Water 74 | 4 | 0.0004375
907172 | 170 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00801106 | 15 | Domestic Cold Water 74 | 5 | 0.0004375
907174 | 100 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00376991 | 12 | Domestic Cold Water 73 | 4 | 0.000583333
907176 | 170 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00640885 | 12 | Domestic Cold Water 73 | 5 | 0.000583333
907178 | 115.34 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00434822 | 12 | Domestic Cold Water 178 | 2 | 0.000583333
907180 | 120 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00452389 | 12 | Domestic Cold Water 178 | 3 | 0.000583333
907182 | 100 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00471239 | 15 | Domestic Cold Water 178 | 1 | 0.0004375
907184 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 181 | 1 | 0.0004375
907186 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 181 | 4 | 0.0004375
907188 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 181 | 3 | 0.00035
907190 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 184 | 1 | 0.0004375
907192 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 184 | 4 | 0.000583333
907194 | 65 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00245044 | 12 | Domestic Cold Water 184 | 3 | 0.000583333
907196 | 51.7891 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0019524 | 12 | Domestic Cold Water 187 | 2 | 0.000583333
907198 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 187 | 3 | 0.00035
907200 | 57.2789 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00215936 | 12 | Domestic Cold Water 187 | 1 | 0.000583333
907202 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 190 | 2 | 0.0004375
907204 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 190 | 3 | 0.000583333
907206 | 95 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00596903 | 20 | Domestic Cold Water 190 | 1 | 0.00035
907208 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 193 | 2 | 0.0004375
907210 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 193 | 3 | 0.0004375
907212 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 193 | 1 | 0.00035
907214 | 70.4 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00442336 | 20 | Domestic Cold Water 196 | 2 | 0.00035
907216 | 85 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00534071 | 20 | Domestic Cold Water 196 | 3 | 0.00035
907218 | 185 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0145299 | 25 | Domestic Cold Water 196 | 1 | 0.000269231
907220 | 55 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00207345 | 12 | Domestic Cold Water 199 | 2 | 0.000583333
907222 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 199 | 3 | 0.0004375
907224 | 130 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00612611 | 15 | Domestic Cold Water 199 | 1 | 0.0004375
907226 | 55 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00259181 | 15 | Domestic Cold Water 202 | 2 | 0.0004375
907228 | 70 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00263894 | 12 | Domestic Cold Water 202 | 3 | 0.000583333
907230 | 110 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00518363 | 15 | Domestic Cold Water 202 | 1 | 0.0004375
907232 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 205 | 2 | 0.00035
907234 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 205 | 3 | 0.0004375
907236 | 135 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0084823 | 20 | Domestic Cold Water 205 | 1 | 0.00035
907238 | 90 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00706858 | 25 | Domestic Cold Water 208 | 2 | 0.000269231
907240 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 208 | 3 | 0.000583333
907242 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 208 | 1 | 0.000269231
907244 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 211 | 2 | 0.000269231
907246 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 211 | 3 | 0.000269231
907248 | 165 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0129591 | 25 | Domestic Cold Water 211 | 1 | 0.000269231
907250 | 134.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0105715 | 25 | Domestic Cold Water 214 | 2 | 0.000269231
907252 | 169.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0133204 | 25 | Domestic Cold Water 214 | 3 | 0.000269231
907254 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 214 | 1 | 0.0004375
907256 | 132.8 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0104301 | 25 | Domestic Cold Water 217 | 2 | 0.000269231
907258 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 217 | 3 | 0.000269231
907260 | 120 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00753982 | 20 | Domestic Cold Water 217 | 1 | 0.00035
907262 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 220 | 2 | 0.000269231
907264 | 135 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0106029 | 25 | Domestic Cold Water 220 | 3 | 0.000269231
907266 | 115 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00903208 | 25 | Domestic Cold Water 220 | 1 | 0.000269231
907268 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 223 | 3 | 0.00035
907270 | 105 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00659734 | 20 | Domestic Cold Water 223 | 4 | 0.00035
907272 | 165 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0103673 | 20 | Domestic Cold Water 223 | 1 | 0.00035
907274 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 226 | 2 | 0.0004375
907276 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 226 | 3 | 0.0004375
907278 | 85 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00400553 | 15 | Domestic Cold Water 226 | 1 | 0.0004375
907280 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 229 | 2 | 0.000583333
907282 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 229 | 3 | 0.000583333
907284 | 95 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00358142 | 12 | Domestic Cold Water 229 | 1 | 0.000583333
907286 | 212.786 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0167122 | 25 | Domestic Cold Water 82 | 4 | 0.000269231
907639 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 107 | 2 | 0.000583333
907665 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 107 | 1 | 0.0004375
907684 | 240.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.011338 | 15 | Domestic Cold Water 109 | 2 | 0.0004375
907704 | 218.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0137539 | 20 | Domestic Cold Water 109 | 1 | 0.00035
907728 | 240.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0151111 | 20 | Domestic Cold Water 111 | 2 | 0.00035
907751 | 216.3 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0169882 | 25 | Domestic Cold Water 111 | 1 | 0.000269231

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML AT coil (133)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: FASTLOC EX+; Type Comments: DN 12-32; Type Name: FASTLOC EX+ ML AT coil; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:FASTLOC EX+ ML AT coil; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: FASTLOC EX+ ML AT coil; Type: FASTLOC EX+ ML AT coil; Type Id: 961043
Constraints - Horizontal Justification: Center; Reference Level: Level 1; Slope: 0; Vertical Justification: Middle
Mechanical - System Type: Domestic Cold Water; Schedule/Type: 12 - 32; Material: FASTLOC EX+ ML coil; Pipe Segment: FASTLOC EX+ ML coil - 12 - 32; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa; Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:FASTLOC EX+ ML AT coil:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) = Dimensions, Length (mm) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | End Middle Elevation (mm) = Lower End Centerline Elevation (mm) = Middle Elevation (mm) = Start Middle Elevation (mm) = Upper End Centerline Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Section | Relative Roughness
962065 | 160 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00603186 | 12 | Domestic Cold Water 236 | 1 | 0.000583333
962067 | 192 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00723823 | 12 | Domestic Cold Water 236 | 1 | 0.000583333
962071 | 180 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0084823 | 15 | Domestic Cold Water 238 | 1 | 0.0004375
962073 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 238 | 1 | 0.0004375
962077 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 240 | 1 | 0.00035
962079 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 240 | 1 | 0.00035
962083 | 200 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.015708 | 25 | Domestic Cold Water 242 | 1 | 0.000269231
962085 | 184 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0144513 | 25 | Domestic Cold Water 242 | 1 | 0.000269231
962089 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 245 | 1 | 0.000269231
962091 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 245 | 2 | 0.000269231
962093 | 240 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 249 | 2 | 0.00035
962095 | 182.7 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0114794 | 20 | Domestic Cold Water 249 | 1 | 0.00035
962097 | 120 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.00565487 | 15 | Domestic Cold Water 252 | 1 | 0.0004375
962099 | 240.3 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.0113239 | 15 | Domestic Cold Water 252 | 2 | 0.0004375
962101 | 120.6 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00454651 | 12 | Domestic Cold Water 254 | 1 | 0.000583333
962103 | 200 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00753982 | 12 | Domestic Cold Water 254 | 2 | 0.000583333
962105 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 234 | 1 | 0.000583333
962107 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 235 | 1 | 0.0004375
962109 | 130.2 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00490842 | 12 | Domestic Cold Water 231 | 3 | 0.000583333
962111 | 190.2 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00717037 | 12 | Domestic Cold Water 232 | 3 | 0.000583333
962113 | 199.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125601 | 20 | Domestic Cold Water 233 | 1 | 0.00035
962115 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 228 | 1 | 0.00035
962117 | 221 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0104144 | 15 | Domestic Cold Water 227 | 3 | 0.0004375
962119 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 225 | 1 | 0.0004375
962121 | 240.4 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00906287 | 12 | Domestic Cold Water 224 | 3 | 0.000583333
962123 | 220 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0082938 | 12 | Domestic Cold Water 213 | 1 | 0.000583333
962125 | 219.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103484 | 15 | Domestic Cold Water 215 | 1 | 0.0004375
962127 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 218 | 1 | 0.0004375
962129 | 250 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.015708 | 20 | Domestic Cold Water 221 | 1 | 0.00035
962131 | 230 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0180642 | 25 | Domestic Cold Water 222 | 1 | 0.000269231
962133 | 280 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0219911 | 25 | Domestic Cold Water 230 | 1 | 0.000269231
962135 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 278 | 1 | 0.000583333
962137 | 237.5 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0111919 | 15 | Domestic Cold Water 280 | 1 | 0.0004375
962139 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 280 | 1 | 0.0004375
962141 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 278 | 1 | 0.000583333
962143 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 284 | 1 | 0.00035
962145 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 284 | 1 | 0.00035
962147 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 287 | 1 | 0.000269231
962149 | 227.1 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0178364 | 25 | Domestic Cold Water 287 | 1 | 0.000269231
962151 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 209 | 3 | 0.000269231
962153 | 202.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0127235 | 20 | Domestic Cold Water 207 | 3 | 0.00035
962155 | 223.9 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.010551 | 15 | Domestic Cold Water 206 | 3 | 0.0004375
962157 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 204 | 3 | 0.000583333
962159 | 150 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00565487 | 12 | Domestic Cold Water 198 | 3 | 0.000583333
962161 | 150 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00706858 | 15 | Domestic Cold Water 200 | 3 | 0.0004375
962163 | 148.7 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0093431 | 20 | Domestic Cold Water 201 | 1 | 0.00035
962165 | 147.5 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0115846 | 25 | Domestic Cold Water 203 | 1 | 0.000269231
962167 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 191 | 3 | 0.000583333
962169 | 180.7 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00851529 | 15 | Domestic Cold Water 192 | 2 | 0.0004375
962171 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 194 | 3 | 0.0004375
962173 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 195 | 2 | 0.00035
962175 | 218.4 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0171531 | 25 | Domestic Cold Water 197 | 2 | 0.000269231
962177 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 188 | 5 | 0.00035
962179 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 186 | 4 | 0.00035
962181 | 162.373 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00765165 | 15 | Domestic Cold Water 183 | 4 | 0.0004375
962183 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 180 | 3 | 0.0004375
962185 | 209.67 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00790439 | 12 | Domestic Cold Water 177 | 4 | 0.000583333
962187 | 174.217 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00656781 | 12 | Domestic Cold Water 175 | 4 | 0.000583333
962189 | 140 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00527788 | 12 | Domestic Cold Water 316 | 1 | 0.000583333
962191 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 316 | 1 | 0.000583333
962193 | 160 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00753982 | 15 | Domestic Cold Water 318 | 1 | 0.0004375
962195 | 179.8 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00847288 | 15 | Domestic Cold Water 318 | 1 | 0.0004375
962197 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 320 | 1 | 0.00035
962199 | 160 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0100531 | 20 | Domestic Cold Water 320 | 1 | 0.00035
962201 | 178 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0139801 | 25 | Domestic Cold Water 322 | 1 | 0.000269231
962203 | 180 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 322 | 1 | 0.000269231
962205 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 173 | 4 | 0.00035
962207 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 173 | 5 | 0.00035
962209 | 135 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00636173 | 15 | Domestic Cold Water 171 | 4 | 0.0004375
962211 | 170 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00801106 | 15 | Domestic Cold Water 171 | 5 | 0.0004375
962213 | 100 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00376991 | 12 | Domestic Cold Water 167 | 4 | 0.000583333
962215 | 170 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00640885 | 12 | Domestic Cold Water 167 | 5 | 0.000583333
962217 | 115.34 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00434822 | 12 | Domestic Cold Water 330 | 2 | 0.000583333
962219 | 120 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00452389 | 12 | Domestic Cold Water 330 | 3 | 0.000583333
962221 | 100 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00471239 | 15 | Domestic Cold Water 330 | 1 | 0.0004375
962223 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 333 | 1 | 0.0004375
962225 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 333 | 4 | 0.0004375
962227 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 333 | 3 | 0.00035
962229 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 336 | 1 | 0.0004375
962231 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 336 | 4 | 0.000583333
962233 | 65 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00245044 | 12 | Domestic Cold Water 336 | 3 | 0.000583333
962235 | 51.7891 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0019524 | 12 | Domestic Cold Water 339 | 2 | 0.000583333
962237 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 339 | 3 | 0.00035
962239 | 57.2789 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00215936 | 12 | Domestic Cold Water 339 | 1 | 0.000583333
962241 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 342 | 2 | 0.0004375
962243 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 342 | 3 | 0.000583333
962245 | 95 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00596903 | 20 | Domestic Cold Water 342 | 1 | 0.00035
962247 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 345 | 2 | 0.0004375
962249 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 345 | 3 | 0.0004375
962251 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 345 | 1 | 0.00035
962253 | 70.4 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00442336 | 20 | Domestic Cold Water 348 | 2 | 0.00035
962255 | 85 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00534071 | 20 | Domestic Cold Water 348 | 3 | 0.00035
962257 | 185 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0145299 | 25 | Domestic Cold Water 348 | 1 | 0.000269231
962259 | 55 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00207345 | 12 | Domestic Cold Water 351 | 2 | 0.000583333
962261 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 351 | 3 | 0.0004375
962263 | 130 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00612611 | 15 | Domestic Cold Water 351 | 1 | 0.0004375
962265 | 55 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00259181 | 15 | Domestic Cold Water 354 | 2 | 0.0004375
962267 | 70 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00263894 | 12 | Domestic Cold Water 354 | 3 | 0.000583333
962269 | 110 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00518363 | 15 | Domestic Cold Water 354 | 1 | 0.0004375
962271 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 357 | 2 | 0.00035
962273 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 357 | 3 | 0.0004375
962275 | 135 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0084823 | 20 | Domestic Cold Water 357 | 1 | 0.00035
962277 | 90 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00706858 | 25 | Domestic Cold Water 360 | 2 | 0.000269231
962279 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 360 | 3 | 0.000583333
962281 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 360 | 1 | 0.000269231
962283 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 363 | 2 | 0.000269231
962285 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 363 | 3 | 0.000269231
962287 | 165 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0129591 | 25 | Domestic Cold Water 363 | 1 | 0.000269231
962289 | 134.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0105715 | 25 | Domestic Cold Water 366 | 2 | 0.000269231
962291 | 169.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0133204 | 25 | Domestic Cold Water 366 | 3 | 0.000269231
962293 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 366 | 1 | 0.0004375
962295 | 132.8 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0104301 | 25 | Domestic Cold Water 369 | 2 | 0.000269231
962297 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 369 | 3 | 0.000269231
962299 | 120 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00753982 | 20 | Domestic Cold Water 369 | 1 | 0.00035
962301 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 372 | 2 | 0.000269231
962303 | 135 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0106029 | 25 | Domestic Cold Water 372 | 3 | 0.000269231
962305 | 115 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00903208 | 25 | Domestic Cold Water 372 | 1 | 0.000269231
962307 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 375 | 3 | 0.00035
962309 | 105 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00659734 | 20 | Domestic Cold Water 375 | 4 | 0.00035
962311 | 165 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0103673 | 20 | Domestic Cold Water 375 | 1 | 0.00035
962313 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 378 | 2 | 0.0004375
962315 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 378 | 3 | 0.0004375
962317 | 85 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00400553 | 15 | Domestic Cold Water 378 | 1 | 0.0004375
962319 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 381 | 2 | 0.000583333
962321 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 381 | 3 | 0.000583333
962323 | 95 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00358142 | 12 | Domestic Cold Water 381 | 1 | 0.000583333
962325 | 212.786 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0167122 | 25 | Domestic Cold Water 189 | 4 | 0.000269231
962331 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 385 | 2 | 0.000583333
962333 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 385 | 1 | 0.0004375
962335 | 240.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.011338 | 15 | Domestic Cold Water 387 | 2 | 0.0004375
962337 | 218.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0137539 | 20 | Domestic Cold Water 387 | 1 | 0.00035
962339 | 240.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0151111 | 20 | Domestic Cold Water 389 | 2 | 0.00035
962341 | 216.3 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0169882 | 25 | Domestic Cold Water 389 | 1 | 0.000269231

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML DE bar (132)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: FASTLOC EX+; Type Comments: DN 12-32; Type Name: FASTLOC EX+ ML DE bar; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:FASTLOC EX+ ML DE bar; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: FASTLOC EX+ ML DE bar; Type: FASTLOC EX+ ML DE bar; Type Id: 961069
Constraints - Horizontal Justification: Center; Reference Level: Level 1; Slope: 0; Vertical Justification: Middle
Mechanical - System Type: Domestic Cold Water; Connection Type: Generic; Material: FASTLOC EX+ ML bar; Pipe Segment: FASTLOC EX+ ML bar - 12 - 32; Roughness: 0.007 mm; Schedule/Type: 12 - 32; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa; Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction: 0 kg/m2/s2; Friction Factor: 0; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:FASTLOC EX+ ML DE bar:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) = Dimensions, Length (mm) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | End Middle Elevation (mm) = Lower End Centerline Elevation (mm) = Middle Elevation (mm) = Start Middle Elevation (mm) = Upper End Centerline Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness | Section
885852 | 160 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00603186 | 12 | Domestic Cold Water 1 | 0.000583333 | 1
885870 | 192 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00723823 | 12 | Domestic Cold Water 1 | 0.000583333 | 1
885887 | 180 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0084823 | 15 | Domestic Cold Water 2 | 0.0004375 | 1
885905 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 2 | 0.0004375 | 1
885922 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 3 | 0.00035 | 1
885942 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 3 | 0.00035 | 1
885964 | 200 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.015708 | 25 | Domestic Cold Water 4 | 0.000269231 | 1
885982 | 184 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0144513 | 25 | Domestic Cold Water 4 | 0.000269231 | 1
885997 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 5 | 0.000269231 | 1
886013 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 5 | 0.000269231 | 2
886033 | 240 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 6 | 0.00035 | 2
886053 | 182.7 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0114794 | 20 | Domestic Cold Water 6 | 0.00035 | 1
886070 | 120 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.00565487 | 15 | Domestic Cold Water 7 | 0.0004375 | 1
886086 | 240.3 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.0113239 | 15 | Domestic Cold Water 7 | 0.0004375 | 2
886107 | 120.6 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00454651 | 12 | Domestic Cold Water 8 | 0.000583333 | 1
886123 | 200 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00753982 | 12 | Domestic Cold Water 8 | 0.000583333 | 2
886138 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 66 | 0.000583333 | 1
886157 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 67 | 0.0004375 | 1
886176 | 130 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00490088 | 12 | Domestic Cold Water 63 | 0.000583333 | 3
886195 | 190 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00716283 | 12 | Domestic Cold Water 64 | 0.000583333 | 3
886216 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 65 | 0.00035 | 1
886235 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 61 | 0.00035 | 1
886252 | 221 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0104144 | 15 | Domestic Cold Water 60 | 0.0004375 | 3
886272 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 59 | 0.0004375 | 1
886293 | 240.4 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00906287 | 12 | Domestic Cold Water 58 | 0.000583333 | 3
886310 | 220 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0082938 | 12 | Domestic Cold Water 9 | 0.000583333 | 1
886332 | 219.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103484 | 15 | Domestic Cold Water 10 | 0.0004375 | 1
886348 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 11 | 0.0004375 | 1
886368 | 250 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.015708 | 20 | Domestic Cold Water 12 | 0.00035 | 1
886388 | 230 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0180642 | 25 | Domestic Cold Water 14 | 0.000269231 | 1
886408 | 280 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0219911 | 25 | Domestic Cold Water 62 | 0.000269231 | 1
886425 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 15 | 0.000583333 | 1
886443 | 237.5 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0111919 | 15 | Domestic Cold Water 17 | 0.0004375 | 1
886463 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 17 | 0.0004375 | 1
886480 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 15 | 0.000583333 | 1
886497 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 18 | 0.00035 | 1
886515 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 18 | 0.00035 | 1
886530 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 20 | 0.000269231 | 1
886550 | 227.1 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0178364 | 25 | Domestic Cold Water 20 | 0.000269231 | 1
886567 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 48 | 0.000269231 | 3
886605 | 202.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0127235 | 20 | Domestic Cold Water 47 | 0.00035 | 3
886622 | 223.9 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.010551 | 15 | Domestic Cold Water 46 | 0.0004375 | 3
886648 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 45 | 0.000583333 | 3
886665 | 150 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00565487 | 12 | Domestic Cold Water 41 | 0.000583333 | 3
886686 | 150 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00706858 | 15 | Domestic Cold Water 42 | 0.0004375 | 3
886703 | 148.7 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0093431 | 20 | Domestic Cold Water 43 | 0.00035 | 1
886722 | 147.5 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0115846 | 25 | Domestic Cold Water 44 | 0.000269231 | 1
886737 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 36 | 0.000583333 | 3
886754 | 180.7 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00851529 | 15 | Domestic Cold Water 37 | 0.0004375 | 2
886775 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 38 | 0.0004375 | 3
886792 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 39 | 0.00035 | 2
886809 | 218.4 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0171531 | 25 | Domestic Cold Water 40 | 0.000269231 | 2
886826 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 34 | 0.00035 | 5
886845 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 33 | 0.00035 | 4
886864 | 162.373 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00765165 | 15 | Domestic Cold Water 32 | 0.0004375 | 4
886883 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 31 | 0.0004375 | 3
886900 | 209.67 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00790439 | 12 | Domestic Cold Water 30 | 0.000583333 | 4
886915 | 174.217 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00656781 | 12 | Domestic Cold Water 29 | 0.000583333 | 4
886932 | 140 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00527788 | 12 | Domestic Cold Water 21 | 0.000583333 | 1
886948 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 21 | 0.000583333 | 1
886963 | 160 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00753982 | 15 | Domestic Cold Water 22 | 0.0004375 | 1
886979 | 179.8 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00847288 | 15 | Domestic Cold Water 22 | 0.0004375 | 1
887000 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 23 | 0.00035 | 1
887016 | 160 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0100531 | 20 | Domestic Cold Water 23 | 0.00035 | 1
887031 | 178 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0139801 | 25 | Domestic Cold Water 24 | 0.000269231 | 1
887047 | 180 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 24 | 0.000269231 | 1
887075 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 19 | 0.00035 | 4
887096 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 19 | 0.00035 | 5
887117 | 135 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00636173 | 15 | Domestic Cold Water 16 | 0.0004375 | 4
887134 | 170 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00801106 | 15 | Domestic Cold Water 16 | 0.0004375 | 5
887151 | 100 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00376991 | 12 | Domestic Cold Water 13 | 0.000583333 | 4
887166 | 170 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00640885 | 12 | Domestic Cold Water 13 | 0.000583333 | 5
887185 | 115.34 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00434822 | 12 | Domestic Cold Water 25 | 0.000583333 | 2
887203 | 120 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00452389 | 12 | Domestic Cold Water 25 | 0.000583333 | 3
887222 | 100 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00471239 | 15 | Domestic Cold Water 25 | 0.0004375 | 1
887304 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 26 | 0.0004375 | 1
887328 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 26 | 0.0004375 | 4
887345 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 26 | 0.00035 | 3
887389 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 27 | 0.0004375 | 1
887407 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 27 | 0.000583333 | 4
887426 | 65 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00245044 | 12 | Domestic Cold Water 27 | 0.000583333 | 3
887443 | 51.7891 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0019524 | 12 | Domestic Cold Water 28 | 0.000583333 | 2
887461 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 28 | 0.00035 | 3
887482 | 57.2789 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00215936 | 12 | Domestic Cold Water 28 | 0.000583333 | 1
887499 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 49 | 0.0004375 | 2
887519 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 49 | 0.000583333 | 3
887536 | 95 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00596903 | 20 | Domestic Cold Water 49 | 0.00035 | 1
887555 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 50 | 0.0004375 | 2
887573 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 50 | 0.0004375 | 3
887590 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 50 | 0.00035 | 1
887609 | 70.4 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00442336 | 20 | Domestic Cold Water 51 | 0.00035 | 2
887629 | 85 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00534071 | 20 | Domestic Cold Water 51 | 0.00035 | 3
887648 | 185 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0145299 | 25 | Domestic Cold Water 51 | 0.000269231 | 1
887665 | 55 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00207345 | 12 | Domestic Cold Water 52 | 0.000583333 | 2
887685 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 52 | 0.0004375 | 3
887704 | 130 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00612611 | 15 | Domestic Cold Water 52 | 0.0004375 | 1
887721 | 55 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00259181 | 15 | Domestic Cold Water 53 | 0.0004375 | 2
887739 | 70 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00263894 | 12 | Domestic Cold Water 53 | 0.000583333 | 3
887756 | 110 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00518363 | 15 | Domestic Cold Water 53 | 0.0004375 | 1
887775 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 54 | 0.00035 | 2
887793 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 54 | 0.0004375 | 3
887810 | 135 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0084823 | 20 | Domestic Cold Water 54 | 0.00035 | 1
887831 | 90 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00706858 | 25 | Domestic Cold Water 55 | 0.000269231 | 2
887858 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 55 | 0.000583333 | 3
887875 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 55 | 0.000269231 | 1
887892 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 56 | 0.000269231 | 2
887912 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 56 | 0.000269231 | 3
887929 | 165 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0129591 | 25 | Domestic Cold Water 56 | 0.000269231 | 1
887948 | 134.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0105715 | 25 | Domestic Cold Water 57 | 0.000269231 | 2
887968 | 169.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0133204 | 25 | Domestic Cold Water 57 | 0.000269231 | 3
887987 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 57 | 0.0004375 | 1
888004 | 132.8 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0104301 | 25 | Domestic Cold Water 68 | 0.000269231 | 2
888024 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 68 | 0.000269231 | 3
888039 | 120 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00753982 | 20 | Domestic Cold Water 68 | 0.00035 | 1
888056 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 69 | 0.000269231 | 2
888074 | 135 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0106029 | 25 | Domestic Cold Water 69 | 0.000269231 | 3
888098 | 115 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00903208 | 25 | Domestic Cold Water 69 | 0.000269231 | 1
888115 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 70 | 0.00035 | 3
888135 | 105 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00659734 | 20 | Domestic Cold Water 70 | 0.00035 | 4
888156 | 165 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0103673 | 20 | Domestic Cold Water 70 | 0.00035 | 1
888173 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 71 | 0.0004375 | 2
888189 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 71 | 0.0004375 | 3
888206 | 85 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00400553 | 15 | Domestic Cold Water 71 | 0.0004375 | 1
888247 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 72 | 0.000583333 | 3
888266 | 95 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00358142 | 12 | Domestic Cold Water 72 | 0.000583333 | 1
888284 | 212.786 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0167122 | 25 | Domestic Cold Water 35 | 0.000269231 | 4
963162 | 220 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0082938 | 12 | Domestic Cold Water 237 | 0.000583333 | 2
963182 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 237 | 0.0004375 | 1
963201 | 220.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103955 | 15 | Domestic Cold Water 239 | 0.0004375 | 2
963221 | 198.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0124973 | 20 | Domestic Cold Water 239 | 0.00035 | 1
963242 | 220.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0138544 | 20 | Domestic Cold Water 241 | 0.00035 | 2
963262 | 196.3 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0154174 | 25 | Domestic Cold Water 241 | 0.000269231 | 1

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML DE coil (133)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005; Description: Drinking water & heating; Manufacturer: REHAU; Model: FASTLOC EX+; Type Comments: DN 12-32; Type Name: FASTLOC EX+ ML DE coil; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:FASTLOC EX+ ML DE coil; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: FASTLOC EX+ ML DE coil; Type: FASTLOC EX+ ML DE coil; Type Id: 729604
Constraints - Horizontal Justification: Center; Reference Level: Level 1; Slope: 0; Vertical Justification: Middle
Mechanical - System Type: Domestic Cold Water; Schedule/Type: 12 - 32; Connection Type: Generic; Material: FASTLOC EX+ ML coil; Pipe Segment: FASTLOC EX+ ML coil - 12 - 32; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Pressure Drop: 0 Pa; Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Reynolds Number: 0; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:FASTLOC EX+ ML DE coil:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) = Dimensions, Length (mm) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | End Middle Elevation (mm) = Lower End Centerline Elevation (mm) = Middle Elevation (mm) = Start Middle Elevation (mm) = Upper End Centerline Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Section | Relative Roughness
961319 | 160 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00603186 | 12 | Domestic Cold Water 165 | 1 | 0.000583333
961321 | 192 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00723823 | 12 | Domestic Cold Water 165 | 1 | 0.000583333
961325 | 180 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0084823 | 15 | Domestic Cold Water 169 | 1 | 0.0004375
961327 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 169 | 1 | 0.0004375
961331 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 172 | 1 | 0.00035
961333 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 172 | 1 | 0.00035
