Properties of the parts of a building model (IFC2X3), part 6 of 6

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML DE coil (133)
Name (Pipe Types:FASTLOC EX+ ML DE coil:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) = Dimensions, Length (mm) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | End Middle Elevation (mm) = Lower End Centerline Elevation (mm) = Middle Elevation (mm) = Start Middle Elevation (mm) = Upper End Centerline Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Section | Relative Roughness
961337 | 200 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.015708 | 25 | Domestic Cold Water 174 | 1 | 0.000269231
961339 | 184 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0144513 | 25 | Domestic Cold Water 174 | 1 | 0.000269231
961343 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 176 | 1 | 0.000269231
961345 | 180 | 0.7 | 13.7 | -2.3 | 26.7 | 29.7 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 176 | 2 | 0.000269231
961347 | 240 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 179 | 2 | 0.00035
961349 | 182.7 | 3.7 | 13.7 | 1.2 | 23.7 | 26.2 | 20 | 25 | 20 mmø | 2.5 | 0.0114794 | 20 | Domestic Cold Water 179 | 1 | 0.00035
961351 | 120 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.00565487 | 15 | Domestic Cold Water 182 | 1 | 0.0004375
961353 | 240.3 | 5.7 | 13.7 | 3.7 | 21.7 | 23.7 | 16 | 20 | 15 mmø | 2 | 0.0113239 | 15 | Domestic Cold Water 182 | 2 | 0.0004375
961355 | 120.6 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00454651 | 12 | Domestic Cold Water 185 | 1 | 0.000583333
961357 | 200 | 7.7 | 13.7 | 5.7 | 19.7 | 21.7 | 12 | 16 | 12 mmø | 2 | 0.00753982 | 12 | Domestic Cold Water 185 | 2 | 0.000583333
961359 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 162 | 1 | 0.000583333
961361 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 163 | 1 | 0.0004375
961363 | 130 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00490088 | 12 | Domestic Cold Water 159 | 3 | 0.000583333
961365 | 190 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00716283 | 12 | Domestic Cold Water 160 | 3 | 0.000583333
961367 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 161 | 1 | 0.00035
961369 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 157 | 1 | 0.00035
961371 | 221 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0104144 | 15 | Domestic Cold Water 156 | 3 | 0.0004375
961373 | 240 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0113097 | 15 | Domestic Cold Water 155 | 1 | 0.0004375
961375 | 240.4 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00906287 | 12 | Domestic Cold Water 154 | 3 | 0.000583333
961377 | 220 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0082938 | 12 | Domestic Cold Water 149 | 1 | 0.000583333
961379 | 219.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103484 | 15 | Domestic Cold Water 150 | 1 | 0.0004375
961381 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 151 | 1 | 0.0004375
961383 | 250 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.015708 | 20 | Domestic Cold Water 152 | 1 | 0.00035
961385 | 230 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0180642 | 25 | Domestic Cold Water 153 | 1 | 0.000269231
961387 | 280 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0219911 | 25 | Domestic Cold Water 158 | 1 | 0.000269231
961389 | 240 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00904779 | 12 | Domestic Cold Water 210 | 1 | 0.000583333
961391 | 237.5 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0111919 | 15 | Domestic Cold Water 212 | 1 | 0.0004375
961393 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 212 | 1 | 0.0004375
961395 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 210 | 1 | 0.000583333
961397 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 216 | 1 | 0.00035
961399 | 200 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0125664 | 20 | Domestic Cold Water 216 | 1 | 0.00035
961401 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 219 | 1 | 0.000269231
961403 | 227.1 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0178364 | 25 | Domestic Cold Water 219 | 1 | 0.000269231
961405 | 220 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0172788 | 25 | Domestic Cold Water 148 | 3 | 0.000269231
961407 | 202.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0127235 | 20 | Domestic Cold Water 147 | 3 | 0.00035
961409 | 223.9 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.010551 | 15 | Domestic Cold Water 146 | 3 | 0.0004375
961411 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 145 | 3 | 0.000583333
961413 | 150 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00565487 | 12 | Domestic Cold Water 139 | 3 | 0.000583333
961415 | 150 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00706858 | 15 | Domestic Cold Water 140 | 3 | 0.0004375
961417 | 148.7 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0093431 | 20 | Domestic Cold Water 142 | 1 | 0.00035
961419 | 147.5 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0115846 | 25 | Domestic Cold Water 144 | 1 | 0.000269231
961421 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 127 | 3 | 0.000583333
961423 | 180.7 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00851529 | 15 | Domestic Cold Water 128 | 2 | 0.0004375
961425 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 129 | 3 | 0.0004375
961427 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 130 | 2 | 0.00035
961429 | 218.4 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0171531 | 25 | Domestic Cold Water 136 | 2 | 0.000269231
961431 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 125 | 5 | 0.00035
961433 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 124 | 4 | 0.00035
961435 | 162.373 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00765165 | 15 | Domestic Cold Water 123 | 4 | 0.0004375
961437 | 220 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.0103673 | 15 | Domestic Cold Water 122 | 3 | 0.0004375
961439 | 209.67 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00790439 | 12 | Domestic Cold Water 121 | 4 | 0.000583333
961441 | 174.217 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00656781 | 12 | Domestic Cold Water 119 | 4 | 0.000583333
961443 | 140 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00527788 | 12 | Domestic Cold Water 244 | 1 | 0.000583333
961445 | 180 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00678584 | 12 | Domestic Cold Water 244 | 1 | 0.000583333
961447 | 160 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00753982 | 15 | Domestic Cold Water 246 | 1 | 0.0004375
961449 | 179.8 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00847288 | 15 | Domestic Cold Water 246 | 1 | 0.0004375
961451 | 180 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0113097 | 20 | Domestic Cold Water 248 | 1 | 0.00035
961453 | 160 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0100531 | 20 | Domestic Cold Water 248 | 1 | 0.00035
961455 | 178 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0139801 | 25 | Domestic Cold Water 250 | 1 | 0.000269231
961457 | 180 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0141372 | 25 | Domestic Cold Water 250 | 1 | 0.000269231
961459 | 240 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0150796 | 20 | Domestic Cold Water 117 | 4 | 0.00035
961461 | 220 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.013823 | 20 | Domestic Cold Water 117 | 5 | 0.00035
961463 | 135 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00636173 | 15 | Domestic Cold Water 115 | 4 | 0.0004375
961465 | 170 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00801106 | 15 | Domestic Cold Water 115 | 5 | 0.0004375
961467 | 100 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00376991 | 12 | Domestic Cold Water 113 | 4 | 0.000583333
961469 | 170 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00640885 | 12 | Domestic Cold Water 113 | 5 | 0.000583333
961471 | 115.34 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00434822 | 12 | Domestic Cold Water 258 | 2 | 0.000583333
961473 | 120 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00452389 | 12 | Domestic Cold Water 258 | 3 | 0.000583333
961475 | 100 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00471239 | 15 | Domestic Cold Water 258 | 1 | 0.0004375
961477 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 261 | 1 | 0.0004375
961479 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 261 | 4 | 0.0004375
961481 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 261 | 3 | 0.00035
961483 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 264 | 1 | 0.0004375
961485 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 264 | 4 | 0.000583333
961487 | 65 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00245044 | 12 | Domestic Cold Water 264 | 3 | 0.000583333
961489 | 51.7891 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0019524 | 12 | Domestic Cold Water 267 | 2 | 0.000583333
961491 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 267 | 3 | 0.00035
961493 | 57.2789 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00215936 | 12 | Domestic Cold Water 267 | 1 | 0.000583333
961495 | 75 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00353429 | 15 | Domestic Cold Water 270 | 2 | 0.0004375
961497 | 50 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00188496 | 12 | Domestic Cold Water 270 | 3 | 0.000583333
961499 | 95 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00596903 | 20 | Domestic Cold Water 270 | 1 | 0.00035
961501 | 60 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00282743 | 15 | Domestic Cold Water 273 | 2 | 0.0004375
961503 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 273 | 3 | 0.0004375
961505 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 273 | 1 | 0.00035
961507 | 70.4 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00442336 | 20 | Domestic Cold Water 276 | 2 | 0.00035
961509 | 85 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00534071 | 20 | Domestic Cold Water 276 | 3 | 0.00035
961511 | 185 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0145299 | 25 | Domestic Cold Water 276 | 1 | 0.000269231
961513 | 55 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00207345 | 12 | Domestic Cold Water 279 | 2 | 0.000583333
961515 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 279 | 3 | 0.0004375
961517 | 130 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00612611 | 15 | Domestic Cold Water 279 | 1 | 0.0004375
961519 | 55 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00259181 | 15 | Domestic Cold Water 282 | 2 | 0.0004375
961521 | 70 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00263894 | 12 | Domestic Cold Water 282 | 3 | 0.000583333
961523 | 110 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00518363 | 15 | Domestic Cold Water 282 | 1 | 0.0004375
961525 | 80 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00502655 | 20 | Domestic Cold Water 285 | 2 | 0.00035
961527 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 285 | 3 | 0.0004375
961529 | 135 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0084823 | 20 | Domestic Cold Water 285 | 1 | 0.00035
961531 | 90 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00706858 | 25 | Domestic Cold Water 288 | 2 | 0.000269231
961533 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 288 | 3 | 0.000583333
961535 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 288 | 1 | 0.000269231
961537 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 291 | 2 | 0.000269231
961539 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 291 | 3 | 0.000269231
961541 | 165 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0129591 | 25 | Domestic Cold Water 291 | 1 | 0.000269231
961543 | 134.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0105715 | 25 | Domestic Cold Water 294 | 2 | 0.000269231
961545 | 169.6 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0133204 | 25 | Domestic Cold Water 294 | 3 | 0.000269231
961547 | 90 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00424115 | 15 | Domestic Cold Water 294 | 1 | 0.0004375
961549 | 132.8 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0104301 | 25 | Domestic Cold Water 297 | 2 | 0.000269231
961551 | 145 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0113883 | 25 | Domestic Cold Water 297 | 3 | 0.000269231
961553 | 120 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00753982 | 20 | Domestic Cold Water 297 | 1 | 0.00035
961555 | 130 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0102102 | 25 | Domestic Cold Water 300 | 2 | 0.000269231
961557 | 135 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0106029 | 25 | Domestic Cold Water 300 | 3 | 0.000269231
961559 | 115 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.00903208 | 25 | Domestic Cold Water 300 | 1 | 0.000269231
961561 | 70 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00439823 | 20 | Domestic Cold Water 303 | 3 | 0.00035
961563 | 105 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.00659734 | 20 | Domestic Cold Water 303 | 4 | 0.00035
961565 | 165 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0103673 | 20 | Domestic Cold Water 303 | 1 | 0.00035
961567 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 306 | 2 | 0.0004375
961569 | 65 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00306305 | 15 | Domestic Cold Water 306 | 3 | 0.0004375
961571 | 85 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00400553 | 15 | Domestic Cold Water 306 | 1 | 0.0004375
961573 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 309 | 2 | 0.000583333
961575 | 90 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00339292 | 12 | Domestic Cold Water 309 | 3 | 0.000583333
961577 | 95 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.00358142 | 12 | Domestic Cold Water 309 | 1 | 0.000583333
961579 | 212.786 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0167122 | 25 | Domestic Cold Water 126 | 4 | 0.000269231
963338 | 280 | -6 | 0 | -8 | 6 | 8 | 12 | 16 | 12 mmø | 2 | 0.0105558 | 12 | Domestic Cold Water 243 | 2 | 0.000583333
963356 | 200 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.00942478 | 15 | Domestic Cold Water 243 | 1 | 0.0004375
963376 | 280.6 | -8 | 0 | -10 | 8 | 10 | 16 | 20 | 15 mmø | 2 | 0.013223 | 15 | Domestic Cold Water 247 | 2 | 0.0004375
963396 | 198.9 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0124973 | 20 | Domestic Cold Water 247 | 1 | 0.00035
963413 | 280.5 | -10 | 0 | -12.5 | 10 | 12.5 | 20 | 25 | 20 mmø | 2.5 | 0.0176243 | 20 | Domestic Cold Water 251 | 2 | 0.00035
963431 | 196.3 | -13 | 0 | -16 | 13 | 16 | 26 | 32 | 25 mmø | 3 | 0.0154174 | 25 | Domestic Cold Water 251 | 1 | 0.000269231
