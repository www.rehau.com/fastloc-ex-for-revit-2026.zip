Properties of the parts of a building model (IFC2X3), part 4 of 6

# IfcFlowFitting: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT (4)
Name (FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT:...) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) = Minimum Size (mm) | Area (m2) | Do1 (mm) | Dr1 (mm) = Dr2 (mm) | H1 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight
906992 | 12 | 0.00918933 | 16 | 13.8 | 12 | 57.7 | 15 mmø-12 mmø-12 mmø | 0.0000108553 | 42.7 | 11.8 | REHAU Backplate elbow double FASTLOC EX+ 16 - Rp 1/2 - 16 | 4067936345694 | 13707361001 | 210
906994 | 15 | 0.0124585 | 20 | 17.6 | 14 | 62.1 | 15 mmø-15 mmø-15 mmø | 0.0000205562 | 44.7 | 9.8 | REHAU Backplate elbow double FASTLOC EX+ 20 - Rp 1/2 - 20 | 4067936345700 | 13707371001 | 241
962035 | 12 | 0.00918933 | 16 | 13.8 | 12 | 57.7 | 15 mmø-12 mmø-12 mmø | 0.0000108553 | 42.7 | 11.8 | REHAU Backplate elbow double FASTLOC EX+ 16 - Rp 1/2 - 16 | 4067936345694 | 13707361001 | 210
962037 | 15 | 0.0124585 | 20 | 17.6 | 14 | 62.1 | 15 mmø-15 mmø-15 mmø | 0.0000205562 | 44.7 | 9.8 | REHAU Backplate elbow double FASTLOC EX+ 20 - Rp 1/2 - 20 | 4067936345700 | 13707371001 | 241

# IfcFlowFitting: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Double-wall-mounted elbow EX+, with internal thread; T1: FSL Double wall mounted Elbow EX+; T2: FSL Double wall mounted Elbow EX+DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - ETIM Class code: EC003025; Manufacturer: REHAU; REHAU Info: 2025.02.27-419114-419114; Type Name: FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE; sets with these values: 2
Other - Family: FASTLOC_Double-wall-mounted elbow EX+, with internal thread; Family and Type: FASTLOC_Double-wall-mounted elbow EX+, with internal thread: FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE; Type: FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE; Type Id: 825689
Constraints - Elevation from Level: 0 mm; Level: Level 1
Construction - Nominal Diameter 2: 15 mm; REH_LONG: no
Data - PID Check: 1 mm
Dimensions - a: 44 deg; D: 57.6 mm; DN2: 15 mm; Do2: 15 mm; Le1: 57 mm; Le2: 50 mm; Maximum Size: 15 mm; n: 5; r: 20 mm; t1: 2.7 mm; t2: 2.7 mm
Graphics - Use Annotation Scale: no
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE:...) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) = Minimum Size (mm) | Area (m2) | Do1 (mm) | Dr1 (mm) = Dr2 (mm) | H1 (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight
869329 | 12 | 0.00918933 | 16 | 13.8 | 12 | 57.7 | 15 mmø-12 mmø-12 mmø | 0.0000108553 | 42.7 | 11.8 | REHAU Backplate elbow double FASTLOC EX+ 16 - Rp 1/2 - 16 | 4067936345694 | 13707361001 | 210
869356 | 15 | 0.0124585 | 20 | 17.6 | 14 | 62.1 | 15 mmø-15 mmø-15 mmø | 0.0000205562 | 44.7 | 9.8 | REHAU Backplate elbow double FASTLOC EX+ 20 - Rp 1/2 - 20 | 4067936345700 | 13707371001 | 241
961289 | 12 | 0.00918933 | 16 | 13.8 | 12 | 57.7 | 15 mmø-12 mmø-12 mmø | 0.0000108553 | 42.7 | 11.8 | REHAU Backplate elbow double FASTLOC EX+ 16 - Rp 1/2 - 16 | 4067936345694 | 13707361001 | 210
961291 | 15 | 0.0124585 | 20 | 17.6 | 14 | 62.1 | 15 mmø-15 mmø-15 mmø | 0.0000205562 | 44.7 | 9.8 | REHAU Backplate elbow double FASTLOC EX+ 20 - Rp 1/2 - 20 | 4067936345700 | 13707371001 | 241

# IfcFlowFitting: FASTLOC_Elbow with female thread EX+:FSL A internal AT (16)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with female thread EX+; T1: FSL Elbow with female thread EX+; T2: FSL Elbow with female thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Elbow with female thread EX+:FSL A internal AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Elbow with female thread EX+; Type: FSL A internal AT; Family and Type: FASTLOC_Elbow with female thread EX+: FSL A internal AT; Type Id: 788036
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; L SLW: 10 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with female thread EX+:FSL A internal AT:...) | V1 | V2 | Angle (deg) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | SLW (mm) | SLW/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906968 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 96
906970 | no | yes | 60 | 10 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000281727 | 22.7 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 20 - Rp 1/2 | 4067936344970 | 13707211001 | 81 | Domestic Cold Water 97
906972 | no | yes | 60 | 11.7 | 15 | 20 | 15.5 | 11.5 | 20 | 28 | 7.75 | 3.875 | 20 mmø-15 mmø | 34 | 17 | 0.0000373801 | 26 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 20 - Rp 3/4 | 4067936344987 | 13707241001 | 115 | Domestic Cold Water 98
906974 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 99
906976 | yes | no | 45 | 15.4 | 25 | 25 | 25 | 19.7 | 25 | 34.5 | 12.5 | 6.25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000791725 | 32 | 6.1 | REHAU Elbow FASTLOC EX+, with fem.thread 32 - Rp 1 | 4067936345601 | 13707261001 | 234 | Domestic Cold Water 100
906983 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 101
906985 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 102
906987 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 103
962011 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 224
962013 | no | yes | 60 | 10 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000281727 | 22.7 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 20 - Rp 1/2 | 4067936344970 | 13707211001 | 81 | Domestic Cold Water 225
962015 | no | yes | 60 | 11.7 | 15 | 20 | 15.5 | 11.5 | 20 | 28 | 7.75 | 3.875 | 20 mmø-15 mmø | 34 | 17 | 0.0000373801 | 26 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 20 - Rp 3/4 | 4067936344987 | 13707241001 | 115 | Domestic Cold Water 227
962017 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 228
962019 | yes | no | 45 | 15.4 | 25 | 25 | 25 | 19.7 | 25 | 34.5 | 12.5 | 6.25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000791725 | 32 | 6.1 | REHAU Elbow FASTLOC EX+, with fem.thread 32 - Rp 1 | 4067936345601 | 13707261001 | 234 | Domestic Cold Water 230
962026 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 231
962028 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Elbow FASTLOC EX+, with fem.thread 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 232
962030 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Elbow FASTLOC EX+, with fem.thread 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 233

# IfcFlowFitting: FASTLOC_Elbow with female thread EX+:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with female thread EX+; T1: FSL Elbow with female thread EX+; T2: FSL Elbow with female thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Elbow with female thread EX+:FSL A internal DE; sets with these values: 2
Other - IsCustom: no; Type: FSL A internal DE; Family: FASTLOC_Elbow with female thread EX+; Family and Type: FASTLOC_Elbow with female thread EX+: FSL A internal DE; Type Id: 825687
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; L SLW: 10 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with female thread EX+:FSL A internal DE:...) | V1 | V2 | Angle (deg) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | r (mm) | r/2 (mm) | Size = Overall Size | SLW (mm) | SLW/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
860846 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Winkelübergang FASTLOC EX+ 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 58
860858 | no | yes | 60 | 10 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000281727 | 22.7 | 5 | REHAU Winkelübergang FASTLOC EX+ 20 - Rp 1/2 | 4067936344970 | 13707211001 | 81 | Domestic Cold Water 59
860870 | no | yes | 60 | 11.7 | 15 | 20 | 15.5 | 11.5 | 20 | 28 | 7.75 | 3.875 | 20 mmø-15 mmø | 34 | 17 | 0.0000373801 | 26 | 5.3 | REHAU Winkelübergang FASTLOC EX+ 20 - Rp 3/4 | 4067936344987 | 13707241001 | 115 | Domestic Cold Water 60
860882 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Winkelübergang FASTLOC EX+ 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 61
860894 | yes | no | 45 | 15.4 | 25 | 25 | 25 | 19.7 | 25 | 34.5 | 12.5 | 6.25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000791725 | 32 | 6.1 | REHAU Winkelübergang FASTLOC EX+ 32 - Rp 1 | 4067936345601 | 13707261001 | 234 | Domestic Cold Water 62
961265 | no | yes | 60 | 8 | 12 | 15 | 11.6 | 7.9 | 15 | 23 | 5.8 | 2.9 | 15 mmø-12 mmø | 27 | 13.5 | 0.0000214491 | 22.3 | 5 | REHAU Winkelübergang FASTLOC EX+ 16 - Rp 1/2 | 4067936344963 | 13707191001 | 68 | Domestic Cold Water 154
961267 | no | yes | 60 | 10 | 15 | 15 | 15.5 | 11.5 | 15 | 25 | 7.75 | 3.875 | 15 mmø-15 mmø | 27 | 13.5 | 0.0000281727 | 22.7 | 5 | REHAU Winkelübergang FASTLOC EX+ 20 - Rp 1/2 | 4067936344970 | 13707211001 | 81 | Domestic Cold Water 155
961269 | no | yes | 60 | 11.7 | 15 | 20 | 15.5 | 11.5 | 20 | 28 | 7.75 | 3.875 | 20 mmø-15 mmø | 34 | 17 | 0.0000373801 | 26 | 5.3 | REHAU Winkelübergang FASTLOC EX+ 20 - Rp 3/4 | 4067936344987 | 13707241001 | 115 | Domestic Cold Water 156
961271 | no | yes | 60 | 12.2 | 20 | 20 | 19.2 | 14.7 | 25 | 28.5 | 9.6 | 4.8 | 20 mmø-20 mmø | 34 | 17 | 0.0000443361 | 27 | 5.3 | REHAU Winkelübergang FASTLOC EX+ 25 - Rp 3/4 | 4067936344994 | 13707251001 | 139 | Domestic Cold Water 157
961273 | yes | no | 45 | 15.4 | 25 | 25 | 25 | 19.7 | 25 | 34.5 | 12.5 | 6.25 | 25 mmø-25 mmø | 41 | 20.5 | 0.0000791725 | 32 | 6.1 | REHAU Winkelübergang FASTLOC EX+ 32 - Rp 1 | 4067936345601 | 13707261001 | 234 | Domestic Cold Water 158

# IfcFlowFitting: FASTLOC_Elbow with male thread EX+:FSL A internal AT (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with male thread EX+; T1: FSL Elbow with male thread EX+; T2: FSL Elbow with male thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Elbow with male thread EX+:FSL A internal AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_Elbow with male thread EX+; Type: FSL A internal AT; Family and Type: FASTLOC_Elbow with male thread EX+: FSL A internal AT; Type Id: 785152
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with male thread EX+:FSL A internal AT:...) | V1 | V2 | r (mm) | r2 (mm) | Angle (deg) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906953 | no | yes | 5.8 | 3.95 | 60 | 9.5 | 12 | 15 | 11.6 | 20.6 | 7.9 | 14 | 29.2 | 15 mmø-12 mmø | 10.5 | 0.0000127713 | 19.8 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 16 - R 1/2 | 4067936345618 | 13707271001 | 59 | Domestic Cold Water 131
906955 | no | yes | 7.8 | 5.75 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.0000195686 | 20.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 20 - R 1/2 | 4067936345625 | 13707281001 | 73 | Domestic Cold Water 132
906957 | yes | no | 7.8 | 5.75 | 45 | 13.8 | 15 | 20 | 15.5 | 26 | 11.5 | 19 | 34.8 | 20 mmø-15 mmø | 13.5 | 0.0000224607 | 23.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 20 - R 3/4 | 4067936345632 | 13707291001 | 89 | Domestic Cold Water 133
906959 | yes | no | 9.6 | 7.35 | 45 | 16.5 | 20 | 20 | 19.2 | 26 | 14.7 | 19 | 37.5 | 20 mmø-20 mmø | 13.5 | 0.0000334866 | 24.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 25 - R 3/4 | 4067936345649 | 13707301001 | 115 | Domestic Cold Water 134
906961 | yes | no | 12.5 | 9.85 | 45 | 21 | 25 | 25 | 25 | 32.6 | 19.7 | 24 | 44.8 | 25 mmø-25 mmø | 17 | 0.0000579524 | 29.7 | 7 | REHAU Elbow FASTLOC EX+, male thread 32 - R 1 | 4067936345656 | 13707311001 | 211 | Domestic Cold Water 135
961996 | no | yes | 5.8 | 3.95 | 60 | 9.5 | 12 | 15 | 11.6 | 20.6 | 7.9 | 14 | 29.2 | 15 mmø-12 mmø | 10.5 | 0.0000127713 | 19.8 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 16 - R 1/2 | 4067936345618 | 13707271001 | 59 | Domestic Cold Water 213
961998 | no | yes | 7.8 | 5.75 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.0000195686 | 20.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 20 - R 1/2 | 4067936345625 | 13707281001 | 73 | Domestic Cold Water 215
962000 | yes | no | 7.8 | 5.75 | 45 | 13.8 | 15 | 20 | 15.5 | 26 | 11.5 | 19 | 34.8 | 20 mmø-15 mmø | 13.5 | 0.0000224607 | 23.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 20 - R 3/4 | 4067936345632 | 13707291001 | 89 | Domestic Cold Water 218
962002 | yes | no | 9.6 | 7.35 | 45 | 16.5 | 20 | 20 | 19.2 | 26 | 14.7 | 19 | 37.5 | 20 mmø-20 mmø | 13.5 | 0.0000334866 | 24.2 | 6.5 | REHAU Elbow FASTLOC EX+, male thread 25 - R 3/4 | 4067936345649 | 13707301001 | 115 | Domestic Cold Water 221
962004 | yes | no | 12.5 | 9.85 | 45 | 21 | 25 | 25 | 25 | 32.6 | 19.7 | 24 | 44.8 | 25 mmø-25 mmø | 17 | 0.0000579524 | 29.7 | 7 | REHAU Elbow FASTLOC EX+, male thread 32 - R 1 | 4067936345656 | 13707311001 | 211 | Domestic Cold Water 222

# IfcFlowFitting: FASTLOC_Elbow with male thread EX+:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_Elbow with male thread EX+; T1: FSL Elbow with male thread EX+; T2: FSL Elbow with male thread EX+ DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL A internal DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Materials and Finishes - REH_MATERIAL: lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_Elbow with male thread EX+:FSL A internal DE; sets with these values: 2
Other - IsCustom: no; Type: FSL A internal DE; Family: FASTLOC_Elbow with male thread EX+; Family and Type: FASTLOC_Elbow with male thread EX+: FSL A internal DE; Type Id: 825685
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_Elbow with male thread EX+:FSL A internal DE:...) | V1 | V2 | r (mm) | r2 (mm) | Angle (deg) | a (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | DoF1 (mm) | DoF2 (mm) | ID1 (mm) | ID2 (mm) | L2 (mm) | Size = Overall Size | SLW (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight | System Name = Group
841754 | no | yes | 5.8 | 3.95 | 60 | 9.5 | 12 | 15 | 11.6 | 20.6 | 7.9 | 14 | 29.2 | 15 mmø-12 mmø | 10.5 | 0.0000127713 | 19.8 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 16 - R 1/2 | 4067936345618 | 13707271001 | 59 | Domestic Cold Water 9
841890 | no | yes | 7.8 | 5.75 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.0000195686 | 20.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 20 - R 1/2 | 4067936345625 | 13707281001 | 73 | Domestic Cold Water 10
842016 | yes | no | 7.8 | 5.75 | 45 | 13.8 | 15 | 20 | 15.5 | 26 | 11.5 | 19 | 34.8 | 20 mmø-15 mmø | 13.5 | 0.0000224607 | 23.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 20 - R 3/4 | 4067936345632 | 13707291001 | 89 | Domestic Cold Water 11
842142 | yes | no | 9.6 | 7.35 | 45 | 16.5 | 20 | 20 | 19.2 | 26 | 14.7 | 19 | 37.5 | 20 mmø-20 mmø | 13.5 | 0.0000334866 | 24.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 25 - R 3/4 | 4067936345649 | 13707301001 | 115 | Domestic Cold Water 12
842260 | yes | no | 12.5 | 9.85 | 45 | 21 | 25 | 25 | 25 | 32.6 | 19.7 | 24 | 44.8 | 25 mmø-25 mmø | 17 | 0.0000579524 | 29.7 | 7 | REHAU Winkelübergang FASTLOC EX+ 32 - R 1 | 4067936345656 | 13707311001 | 211 | Domestic Cold Water 14
961250 | no | yes | 5.8 | 3.95 | 60 | 9.5 | 12 | 15 | 11.6 | 20.6 | 7.9 | 14 | 29.2 | 15 mmø-12 mmø | 10.5 | 0.0000127713 | 19.8 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 16 - R 1/2 | 4067936345618 | 13707271001 | 59 | Domestic Cold Water 149
961252 | no | yes | 7.8 | 5.75 | 60 | 13.8 | 15 | 15 | 15.5 | 20.6 | 11.5 | 14 | 33.5 | 15 mmø-15 mmø | 10.5 | 0.0000195686 | 20.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 20 - R 1/2 | 4067936345625 | 13707281001 | 73 | Domestic Cold Water 150
961254 | yes | no | 7.8 | 5.75 | 45 | 13.8 | 15 | 20 | 15.5 | 26 | 11.5 | 19 | 34.8 | 20 mmø-15 mmø | 13.5 | 0.0000224607 | 23.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 20 - R 3/4 | 4067936345632 | 13707291001 | 89 | Domestic Cold Water 151
961256 | yes | no | 9.6 | 7.35 | 45 | 16.5 | 20 | 20 | 19.2 | 26 | 14.7 | 19 | 37.5 | 20 mmø-20 mmø | 13.5 | 0.0000334866 | 24.2 | 6.5 | REHAU Winkelübergang FASTLOC EX+ 25 - R 3/4 | 4067936345649 | 13707301001 | 115 | Domestic Cold Water 152
961258 | yes | no | 12.5 | 9.85 | 45 | 21 | 25 | 25 | 25 | 32.6 | 19.7 | 24 | 44.8 | 25 mmø-25 mmø | 17 | 0.0000579524 | 29.7 | 7 | REHAU Winkelübergang FASTLOC EX+ 32 - R 1 | 4067936345656 | 13707311001 | 211 | Domestic Cold Water 153

# IfcFlowFitting: FASTLOC_ML_bend:FSL ML AT (7)
In: Level 1
Type - Material: FASTLOC EX+ ML
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_ML_bend
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_PRICE_LIST: DE_2024; REHAU Info: 2024.05.05-419114-419114; Type Name: FSL ML AT; URL: https://oxomi.com/p/3000126/products?oxDeeplink=ewAiAG4AYQB2AFAAcgBvAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgBzAGUAcgBpAGUAcwAiADoAWwAiADEAOQBBAFUARwBGAEUAUwBJADQAUwBQAEQANQAzAFEAOABLAEMASwA3AEYAMwBNAFQAOAAiAF0ALAAiAG0AZQB0AGEAYwBsAGEAcwBzACIAOgBbACIAbQBlAHQAYQBjAGwAYQBzAHMAfABFAEMAMAAxADAAMgAyADUAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgAiACwAIgBoAGkAZABkAGUAbgBGAGkAbAB0AGUAcgBzACIAOgB7ACIAYgByAGEAbgBkACIAOgBbACIAUgBLAEgATABRADEAUwBSAEEAVgBEAE4AUQBHAEcARABQAEsAMgBRAEEAQQAwAEcAMgBPACIAXQB9AH0AfQA%3D
Type - Materials and Finishes - FASTLOC material: FASTLOC EX+ ML
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: FASTLOC_ML_bend:FSL ML AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_ML_bend; Family and Type: FASTLOC_ML_bend: FSL ML AT; Type: FSL ML AT; Type Id: 825683
Constraints - Elevation from Level: 0 mm; Level: Level 1
Dimensions - Angle: 90 deg; Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_ML_bend:FSL ML AT:...) | NominalDiameter = Nominal Diameter (mm) = Maximum Size (mm) = Minimum Size (mm) | DO (mm) | R (mm) = Z1 (mm) | Size = Overall Size | Volume (m3) | System Name = Group
907030 | 12 | 16 | 128 | 12 mmø-12 mmø | 0.0000223346 | Domestic Cold Water 106
907036 | 15 | 20 | 160 | 15 mmø-15 mmø | 0.0000391535 | Domestic Cold Water 108
907042 | 20 | 25 | 200 | 20 mmø-20 mmø | 0.00007778 | Domestic Cold Water 110
962069 | 12 | 16 | 128 | 12 mmø-12 mmø | 0.0000223346 | Domestic Cold Water 236
962075 | 15 | 20 | 160 | 15 mmø-15 mmø | 0.0000391535 | Domestic Cold Water 238
962081 | 20 | 25 | 200 | 20 mmø-20 mmø | 0.00007778 | Domestic Cold Water 240
962087 | 25 | 32 | 256 | 25 mmø-25 mmø | 0.00016209 | Domestic Cold Water 242

# IfcFlowFitting: FASTLOC_ML_bend:FSL ML DE (9)
In: Level 1
Type - Material: FASTLOC EX+ ML
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_ML_bend
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_PRICE_LIST: DE_2024; REHAU Info: 2024.05.05-419114-419114; Type Name: FSL ML DE; URL: https://oxomi.com/p/3000126/products?oxDeeplink=ewAiAG4AYQB2AFAAcgBvAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgBzAGUAcgBpAGUAcwAiADoAWwAiADEAOQBBAFUARwBGAEUAUwBJADQAUwBQAEQANQAzAFEAOABLAEMASwA3AEYAMwBNAFQAOAAiAF0ALAAiAG0AZQB0AGEAYwBsAGEAcwBzACIAOgBbACIAbQBlAHQAYQBjAGwAYQBzAHMAfABFAEMAMAAxADAAMgAyADUAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgAiACwAIgBoAGkAZABkAGUAbgBGAGkAbAB0AGUAcgBzACIAOgB7ACIAYgByAGEAbgBkACIAOgBbACIAUgBLAEgATABRADEAUwBSAEEAVgBEAE4AUQBHAEcARABQAEsAMgBRAEEAQQAwAEcAMgBPACIAXQB9AH0AfQA%3D
Type - Materials and Finishes - FASTLOC material: FASTLOC EX+ ML
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: FASTLOC_ML_bend:FSL ML DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_ML_bend; Family and Type: FASTLOC_ML_bend: FSL ML DE; Type: FSL ML DE; Type Id: 825594
Constraints - Elevation from Level: 0 mm; Level: Level 1
Dimensions - Angle: 90 deg; Area: 0.00281399 m2
Graphics - Use Annotation Scale: no
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_ML_bend:FSL ML DE:...) | NominalDiameter = Nominal Diameter (mm) = Maximum Size (mm) = Minimum Size (mm) | DO (mm) | R (mm) = Z1 (mm) | Size = Overall Size | Volume (m3) | System Name = Group
885876 | 12 | 16 | 128 | 12 mmø-12 mmø | 0.0000223346 | Domestic Cold Water 1
885911 | 15 | 20 | 160 | 15 mmø-15 mmø | 0.0000391535 | Domestic Cold Water 2
885948 | 20 | 25 | 200 | 20 mmø-20 mmø | 0.00007778 | Domestic Cold Water 3
885988 | 25 | 32 | 256 | 25 mmø-25 mmø | 0.00016209 | Domestic Cold Water 4
907048 | 25 | 32 | 256 | 25 mmø-25 mmø | 0.00016209 | Domestic Cold Water 112
961323 | 12 | 16 | 128 | 12 mmø-12 mmø | 0.0000223346 | Domestic Cold Water 165
961329 | 15 | 20 | 160 | 15 mmø-15 mmø | 0.0000391535 | Domestic Cold Water 169
961335 | 20 | 25 | 200 | 20 mmø-20 mmø | 0.00007778 | Domestic Cold Water 172
961341 | 25 | 32 | 256 | 25 mmø-25 mmø | 0.00016209 | Domestic Cold Water 174

# IfcFlowFitting: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece internal thread EX+; T1: FSL T-piece internal thread EX+; T2: FSL T-piece internal thread DN1+3 EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL T thread EX+ AT; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ AT; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_T-piece internal thread EX+; Family and Type: FASTLOC_T-piece internal thread EX+: FSL T thread EX+ AT; Type: FSL T thread EX+ AT; Type Id: 782197
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; ID2: 15 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025; GTIN: 4.06794E+12
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece internal thread EX+:FSL T thread EX+ AT:...) | DN1 (mm) = DN3 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) = ID3 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | Description long | PID | Weight | System Name = Group
906858 | 12 | 15 | 7.9 | 15 mmø-12 mmø-12 mmø | 0.0000235577 | 22 | 9.4 | REHAU T-piece FASTLOC EX+ 16 - Rp 1/2 - 16 | 13706761001 | 83 | Domestic Cold Water 73
906860 | 15 | 15 | 11.5 | 15 mmø-15 mmø-15 mmø | 0.0000357085 | 22.5 | 10.4 | REHAU T-piece FASTLOC EX+ 20 - Rp 1/2 - 20 | 13706771001 | 103 | Domestic Cold Water 74
906862 | 20 | 20 | 14.7 | 20 mmø-20 mmø-20 mmø | 0.000065482 | 26.7 | 12.2 | REHAU T-piece FASTLOC EX+ 25 - Rp 3/4 - 25 | 13706781001 | 178 | Domestic Cold Water 75
961901 | 12 | 15 | 7.9 | 15 mmø-12 mmø-12 mmø | 0.0000235577 | 22 | 9.4 | REHAU T-piece FASTLOC EX+ 16 - Rp 1/2 - 16 | 13706761001 | 83 | Domestic Cold Water 167
961903 | 15 | 15 | 11.5 | 15 mmø-15 mmø-15 mmø | 0.0000357085 | 22.5 | 10.4 | REHAU T-piece FASTLOC EX+ 20 - Rp 1/2 - 20 | 13706771001 | 103 | Domestic Cold Water 171
961905 | 20 | 20 | 14.7 | 20 mmø-20 mmø-20 mmø | 0.000065482 | 26.7 | 12.2 | REHAU T-piece FASTLOC EX+ 25 - Rp 3/4 - 25 | 13706781001 | 178 | Domestic Cold Water 173

# IfcFlowFitting: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ DE (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece internal thread EX+; T1: FSL T-piece internal thread EX+; T2: FSL T-piece internal thread DN1+3 EX+
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Name: FSL T thread EX+ DE; URL: https://oxomi.com/p/3000126/search?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAIgB0AGEAZwAiADoAWwBdACwAIgBjAGEAdABlAGcAbwByAHkAIgA6AFsAIgA1AFQANQBDAEoASQA2AEwAVQBRAEcANQBRAEUANgBWAFAANwA5AFQAUABGAFEAUwA0AEMAIgBdAH0ALAAiAHEAdQBlAHIAeQAiADoAIgBSAEEAVQBUAEkAVABBAE4AIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA1ADAANAA2ADcAMwAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAVABJAFQAQQBOACIALAAiAHMAaQBuAGcAbABlAFAAYQBnAGUAIgA6AHQAcgB1AGUALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoAMQB9AH0AfQA%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ DE; sets with these values: 2
Other - IsCustom: no; Family: FASTLOC_T-piece internal thread EX+; Family and Type: FASTLOC_T-piece internal thread EX+: FSL T thread EX+ DE; Type: FSL T thread EX+ DE; Type Id: 825679
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2; ID2: 15 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025; GTIN: 4.06794E+12
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece internal thread EX+:FSL T thread EX+ DE:...) | DN1 (mm) = DN3 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | ID1 (mm) = ID3 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | Description long | PID | Weight | System Name = Group
827136 | 12 | 15 | 7.9 | 15 mmø-12 mmø-12 mmø | 0.0000235577 | 22 | 9.4 | REHAU T-Stück FASTLOC EX+ 16 - Rp 1/2 - 16 | 13706761001 | 83 | Domestic Cold Water 13
827152 | 15 | 15 | 11.5 | 15 mmø-15 mmø-15 mmø | 0.0000357085 | 22.5 | 10.4 | REHAU T-Stück FASTLOC EX+ 20 - Rp 1/2 - 20 | 13706771001 | 103 | Domestic Cold Water 16
827168 | 20 | 20 | 14.7 | 20 mmø-20 mmø-20 mmø | 0.000065482 | 26.7 | 12.2 | REHAU T-Stück FASTLOC EX+ 25 - Rp 3/4 - 25 | 13706781001 | 178 | Domestic Cold Water 19
961155 | 12 | 15 | 7.9 | 15 mmø-12 mmø-12 mmø | 0.0000235577 | 22 | 9.4 | REHAU T-Stück FASTLOC EX+ 16 - Rp 1/2 - 16 | 13706761001 | 83 | Domestic Cold Water 113
961157 | 15 | 15 | 11.5 | 15 mmø-15 mmø-15 mmø | 0.0000357085 | 22.5 | 10.4 | REHAU T-Stück FASTLOC EX+ 20 - Rp 1/2 - 20 | 13706771001 | 103 | Domestic Cold Water 115
961159 | 20 | 20 | 14.7 | 20 mmø-20 mmø-20 mmø | 0.000065482 | 26.7 | 12.2 | REHAU T-Stück FASTLOC EX+ 25 - Rp 3/4 - 25 | 13706781001 | 178 | Domestic Cold Water 117

# IfcFlowFitting: FASTLOC_T-piece_EX+:FSL T-Piece EX+ AT (36)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece_EX+; T1: FSL T-piece EX+; T2: FSL T-piece EX+ DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check AT; Region PID: PID AT
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.27.43.00; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Comments: bim@rehau.com; Type Name: FSL T-Piece EX+ AT
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece_EX+:FSL T-Piece EX+ AT; sets with these values: 2
Other - Family: FASTLOC_T-piece_EX+; IsCustom: no; Family and Type: FASTLOC_T-piece_EX+: FSL T-Piece EX+ AT; Type: FSL T-Piece EX+ AT; Type Id: 779330
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.000461378 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Type: Domestic Cold Water; System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece_EX+:FSL T-Piece EX+ AT:...) | V1 | V2 | DN1 (mm) | DN2 (mm) | DN3 (mm) | ID 3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight | System Name = Group
906822 | yes | no | 12 | 12 | 12 | 7.9 | 12 | 12 | 12 mmø-12 mmø-12 mmø | 0.0000222654 | 15 | 22.1 | 15 | REHAU T-Stück FASTLOC EX+ 16 - 16 - 16 | 4067936344628 | 13706531001 | 52 | Domestic Cold Water 229
906824 | yes | no | 15 | 15 | 15 | 11.5 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000407468 | 17.2 | 26.4 | 17.2 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 20 | 4067936344635 | 13706541001 | 84 | Domestic Cold Water 226
906826 | yes | no | 20 | 20 | 20 | 14.7 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000710435 | 19.9 | 29.5 | 19.9 | REHAU T-Stück FASTLOC EX+ 25 - 25 - 25 | 4067936344642 | 13706551001 | 153 | Domestic Cold Water 223
906828 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 220
906830 | yes | no | 15 | 12 | 15 | 11.5 | 15 | 12 | 15 mmø-15 mmø-12 mmø | 0.0000342709 | 15.3 | 26.3 | 15.3 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 20 | 4067936344666 | 13706571001 | 71 | Domestic Cold Water 202
906832 | yes | no | 20 | 15 | 20 | 14.7 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000605091 | 18.1 | 29.2 | 18.1 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 25 | 4067936344680 | 13706591001 | 128 | Domestic Cold Water 205
906834 | yes | no | 25 | 12 | 25 | 19.7 | 25 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000853543 | 18.3 | 33.9 | 18.3 | REHAU T-Stück FASTLOC EX+ 32 - 16 - 32 | 4067936344697 | 13706611001 | 196 | Domestic Cold Water 208
906836 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 211
906838 | yes | no | 25 | 15 | 25 | 19.7 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000929587 | 20.2 | 34 | 20.2 | REHAU T-Stück FASTLOC EX+ 32 - 20 - 32 | 4067936345106 | 13706631001 | 211 | Domestic Cold Water 214
906840 | yes | no | 25 | 20 | 25 | 19.7 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.000103383 | 22 | 34.4 | 22 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 32 | 4067936345113 | 13706641001 | 237 | Domestic Cold Water 217
906842 | no | yes | 15 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-15 mmø | 0.0000351338 | 17.4 | 26.4 | 17 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 16 | 4067936345120 | 13706651001 | 78 | Domestic Cold Water 199
906844 | no | yes | 15 | 12 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000286751 | 15.5 | 26.4 | 15.1 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 16 | 4067936386291 | 13706661001 | 65 | Domestic Cold Water 184
906846 | no | yes | 25 | 20 | 20 | 14.7 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000886389 | 22.1 | 34.4 | 20.1 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 25 | 4067936345175 | 13706711001 | 203 | Domestic Cold Water 196
906848 | no | yes | 20 | 12 | 12 | 7.9 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000392659 | 16.4 | 29.1 | 15.1 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 16 | 4067936345144 | 13706671001 | 88 | Domestic Cold Water 187
906850 | no | yes | 20 | 12 | 15 | 11.5 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000444968 | 16.4 | 29.1 | 15.5 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 20 | 4067936345151 | 13706681001 | 96 | Domestic Cold Water 190
906852 | no | yes | 20 | 15 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000511609 | 18.3 | 29.2 | 17.4 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 20 | 4067936345168 | 13706691001 | 111 | Domestic Cold Water 193
906854 | yes | no | 12 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000282262 | 16.9 | 22.3 | 16.9 | REHAU T-Stück FASTLOC EX+ 16 - 20 - 16 | 4067936345182 | 13706731001 | 203 | Domestic Cold Water 178
906856 | yes | no | 15 | 20 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000524178 | 19 | 26.8 | 19 | REHAU T-Stück FASTLOC EX+ 20 - 25 - 20 | 4067936344833 | 13707781001 | 111 | Domestic Cold Water 181
961865 | yes | no | 12 | 12 | 12 | 7.9 | 12 | 12 | 12 mmø-12 mmø-12 mmø | 0.0000222654 | 15 | 22.1 | 15 | REHAU T-Stück FASTLOC EX+ 16 - 16 - 16 | 4067936344628 | 13706531001 | 52 | Domestic Cold Water 381
961867 | yes | no | 15 | 15 | 15 | 11.5 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000407468 | 17.2 | 26.4 | 17.2 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 20 | 4067936344635 | 13706541001 | 84 | Domestic Cold Water 378
961869 | yes | no | 20 | 20 | 20 | 14.7 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000710435 | 19.9 | 29.5 | 19.9 | REHAU T-Stück FASTLOC EX+ 25 - 25 - 25 | 4067936344642 | 13706551001 | 153 | Domestic Cold Water 375
961871 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 372
961873 | yes | no | 15 | 12 | 15 | 11.5 | 15 | 12 | 15 mmø-15 mmø-12 mmø | 0.0000342709 | 15.3 | 26.3 | 15.3 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 20 | 4067936344666 | 13706571001 | 71 | Domestic Cold Water 354
961875 | yes | no | 20 | 15 | 20 | 14.7 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000605091 | 18.1 | 29.2 | 18.1 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 25 | 4067936344680 | 13706591001 | 128 | Domestic Cold Water 357
961877 | yes | no | 25 | 12 | 25 | 19.7 | 25 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000853543 | 18.3 | 33.9 | 18.3 | REHAU T-Stück FASTLOC EX+ 32 - 16 - 32 | 4067936344697 | 13706611001 | 196 | Domestic Cold Water 360
961879 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 363
961881 | yes | no | 25 | 15 | 25 | 19.7 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000929587 | 20.2 | 34 | 20.2 | REHAU T-Stück FASTLOC EX+ 32 - 20 - 32 | 4067936345106 | 13706631001 | 211 | Domestic Cold Water 366
961883 | yes | no | 25 | 20 | 25 | 19.7 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.000103383 | 22 | 34.4 | 22 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 32 | 4067936345113 | 13706641001 | 237 | Domestic Cold Water 369
961885 | no | yes | 15 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-15 mmø | 0.0000351338 | 17.4 | 26.4 | 17 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 16 | 4067936345120 | 13706651001 | 78 | Domestic Cold Water 351
961887 | no | yes | 15 | 12 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000286751 | 15.5 | 26.4 | 15.1 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 16 | 4067936386291 | 13706661001 | 65 | Domestic Cold Water 336
961889 | no | yes | 25 | 20 | 20 | 14.7 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000886389 | 22.1 | 34.4 | 20.1 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 25 | 4067936345175 | 13706711001 | 203 | Domestic Cold Water 348
961891 | no | yes | 20 | 12 | 12 | 7.9 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000392659 | 16.4 | 29.1 | 15.1 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 16 | 4067936345144 | 13706671001 | 88 | Domestic Cold Water 339
961893 | no | yes | 20 | 12 | 15 | 11.5 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000444968 | 16.4 | 29.1 | 15.5 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 20 | 4067936345151 | 13706681001 | 96 | Domestic Cold Water 342
961895 | no | yes | 20 | 15 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000511609 | 18.3 | 29.2 | 17.4 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 20 | 4067936345168 | 13706691001 | 111 | Domestic Cold Water 345
961897 | yes | no | 12 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000282262 | 16.9 | 22.3 | 16.9 | REHAU T-Stück FASTLOC EX+ 16 - 20 - 16 | 4067936345182 | 13706731001 | 203 | Domestic Cold Water 330
961899 | yes | no | 15 | 20 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000524178 | 19 | 26.8 | 19 | REHAU T-Stück FASTLOC EX+ 20 - 25 - 20 | 4067936344833 | 13707781001 | 111 | Domestic Cold Water 333

# IfcFlowFitting: FASTLOC_T-piece_EX+:FSL T-Piece EX+ DE (36)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Other - Category: Pipe Fittings; Family Name: FASTLOC_T-piece_EX+; T1: FSL T-piece EX+; T2: FSL T-piece EX+ DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description DE; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.27.43.00; Manufacturer: REHAU; Model: FASTLOC EX+; REHAU Info: 2025.02.27-419114-419114; Type Comments: bim@rehau.com; Type Name: FSL T-Piece EX+ DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FASTLOC_T-piece_EX+:FSL T-Piece EX+ DE; sets with these values: 2
Other - Family: FASTLOC_T-piece_EX+; Family and Type: FASTLOC_T-piece_EX+: FSL T-Piece EX+ DE; IsCustom: no; Type: FSL T-Piece EX+ DE; Type Id: 825677
Constraints - Elevation from Level: 0 mm; Level: Level 1
Data - PID Check: 1 mm
Dimensions - Area: 0.000461378 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Domestic Cold Water; System Type: Domestic Cold Water
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (FASTLOC_T-piece_EX+:FSL T-Piece EX+ DE:...) | V1 | V2 | DN1 (mm) | DN2 (mm) | DN3 (mm) | ID 3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight | System Name = Group
825953 | yes | no | 12 | 12 | 12 | 7.9 | 12 | 12 | 12 mmø-12 mmø-12 mmø | 0.0000222654 | 15 | 22.1 | 15 | REHAU T-Stück FASTLOC EX+ 16 - 16 - 16 | 4067936344628 | 13706531001 | 52 | Domestic Cold Water 72
826348 | yes | no | 15 | 15 | 15 | 11.5 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000407468 | 17.2 | 26.4 | 17.2 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 20 | 4067936344635 | 13706541001 | 84 | Domestic Cold Water 71
826391 | yes | no | 20 | 20 | 20 | 14.7 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000710435 | 19.9 | 29.5 | 19.9 | REHAU T-Stück FASTLOC EX+ 25 - 25 - 25 | 4067936344642 | 13706551001 | 153 | Domestic Cold Water 70
826399 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 69
826479 | yes | no | 15 | 12 | 15 | 11.5 | 15 | 12 | 15 mmø-15 mmø-12 mmø | 0.0000342709 | 15.3 | 26.3 | 15.3 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 20 | 4067936344666 | 13706571001 | 71 | Domestic Cold Water 53
826487 | yes | no | 20 | 15 | 20 | 14.7 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000605091 | 18.1 | 29.2 | 18.1 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 25 | 4067936344680 | 13706591001 | 128 | Domestic Cold Water 54
826495 | yes | no | 25 | 12 | 25 | 19.7 | 25 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000853543 | 18.3 | 33.9 | 18.3 | REHAU T-Stück FASTLOC EX+ 32 - 16 - 32 | 4067936344697 | 13706611001 | 196 | Domestic Cold Water 55
826503 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 56
826593 | yes | no | 25 | 15 | 25 | 19.7 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000929587 | 20.2 | 34 | 20.2 | REHAU T-Stück FASTLOC EX+ 32 - 20 - 32 | 4067936345106 | 13706631001 | 211 | Domestic Cold Water 57
826601 | yes | no | 25 | 20 | 25 | 19.7 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.000103383 | 22 | 34.4 | 22 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 32 | 4067936345113 | 13706641001 | 237 | Domestic Cold Water 68
826663 | no | yes | 15 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-15 mmø | 0.0000351338 | 17.4 | 26.4 | 17 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 16 | 4067936345120 | 13706651001 | 78 | Domestic Cold Water 52
826747 | no | yes | 15 | 12 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000286751 | 15.5 | 26.4 | 15.1 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 16 | 4067936386291 | 13706661001 | 65 | Domestic Cold Water 27
826755 | no | yes | 25 | 20 | 20 | 14.7 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000886389 | 22.1 | 34.4 | 20.1 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 25 | 4067936345175 | 13706711001 | 203 | Domestic Cold Water 51
826763 | no | yes | 20 | 12 | 12 | 7.9 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000392659 | 16.4 | 29.1 | 15.1 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 16 | 4067936345144 | 13706671001 | 88 | Domestic Cold Water 28
826771 | no | yes | 20 | 12 | 15 | 11.5 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000444968 | 16.4 | 29.1 | 15.5 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 20 | 4067936345151 | 13706681001 | 96 | Domestic Cold Water 49
826779 | no | yes | 20 | 15 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000511609 | 18.3 | 29.2 | 17.4 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 20 | 4067936345168 | 13706691001 | 111 | Domestic Cold Water 50
827048 | yes | no | 12 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000282262 | 16.9 | 22.3 | 16.9 | REHAU T-Stück FASTLOC EX+ 16 - 20 - 16 | 4067936345182 | 13706731001 | 203 | Domestic Cold Water 25
827056 | yes | no | 15 | 20 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000524178 | 19 | 26.8 | 19 | REHAU T-Stück FASTLOC EX+ 20 - 25 - 20 | 4067936344833 | 13707781001 | 111 | Domestic Cold Water 26
961119 | yes | no | 12 | 12 | 12 | 7.9 | 12 | 12 | 12 mmø-12 mmø-12 mmø | 0.0000222654 | 15 | 22.1 | 15 | REHAU T-Stück FASTLOC EX+ 16 - 16 - 16 | 4067936344628 | 13706531001 | 52 | Domestic Cold Water 309
961121 | yes | no | 15 | 15 | 15 | 11.5 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000407468 | 17.2 | 26.4 | 17.2 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 20 | 4067936344635 | 13706541001 | 84 | Domestic Cold Water 306
961123 | yes | no | 20 | 20 | 20 | 14.7 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000710435 | 19.9 | 29.5 | 19.9 | REHAU T-Stück FASTLOC EX+ 25 - 25 - 25 | 4067936344642 | 13706551001 | 153 | Domestic Cold Water 303
961125 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 300
961127 | yes | no | 15 | 12 | 15 | 11.5 | 15 | 12 | 15 mmø-15 mmø-12 mmø | 0.0000342709 | 15.3 | 26.3 | 15.3 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 20 | 4067936344666 | 13706571001 | 71 | Domestic Cold Water 282
961129 | yes | no | 20 | 15 | 20 | 14.7 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000605091 | 18.1 | 29.2 | 18.1 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 25 | 4067936344680 | 13706591001 | 128 | Domestic Cold Water 285
961131 | yes | no | 25 | 12 | 25 | 19.7 | 25 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000853543 | 18.3 | 33.9 | 18.3 | REHAU T-Stück FASTLOC EX+ 32 - 16 - 32 | 4067936344697 | 13706611001 | 196 | Domestic Cold Water 288
961133 | yes | no | 25 | 25 | 25 | 19.7 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.000121223 | 24.8 | 36.1 | 24.8 | REHAU T-Stück FASTLOC EX+ 32 - 32 - 32 | 4067936344659 | 13706561001 | 287 | Domestic Cold Water 291
961135 | yes | no | 25 | 15 | 25 | 19.7 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000929587 | 20.2 | 34 | 20.2 | REHAU T-Stück FASTLOC EX+ 32 - 20 - 32 | 4067936345106 | 13706631001 | 211 | Domestic Cold Water 294
961137 | yes | no | 25 | 20 | 25 | 19.7 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.000103383 | 22 | 34.4 | 22 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 32 | 4067936345113 | 13706641001 | 237 | Domestic Cold Water 297
961139 | no | yes | 15 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-15 mmø | 0.0000351338 | 17.4 | 26.4 | 17 | REHAU T-Stück FASTLOC EX+ 20 - 20 - 16 | 4067936345120 | 13706651001 | 78 | Domestic Cold Water 279
961141 | no | yes | 15 | 12 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000286751 | 15.5 | 26.4 | 15.1 | REHAU T-Stück FASTLOC EX+ 20 - 16 - 16 | 4067936386291 | 13706661001 | 65 | Domestic Cold Water 264
961143 | no | yes | 25 | 20 | 20 | 14.7 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000886389 | 22.1 | 34.4 | 20.1 | REHAU T-Stück FASTLOC EX+ 32 - 25 - 25 | 4067936345175 | 13706711001 | 203 | Domestic Cold Water 276
961145 | no | yes | 20 | 12 | 12 | 7.9 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000392659 | 16.4 | 29.1 | 15.1 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 16 | 4067936345144 | 13706671001 | 88 | Domestic Cold Water 267
961147 | no | yes | 20 | 12 | 15 | 11.5 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000444968 | 16.4 | 29.1 | 15.5 | REHAU T-Stück FASTLOC EX+ 25 - 16 - 20 | 4067936345151 | 13706681001 | 96 | Domestic Cold Water 270
961149 | no | yes | 20 | 15 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000511609 | 18.3 | 29.2 | 17.4 | REHAU T-Stück FASTLOC EX+ 25 - 20 - 20 | 4067936345168 | 13706691001 | 111 | Domestic Cold Water 273
961151 | yes | no | 12 | 15 | 12 | 7.9 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000282262 | 16.9 | 22.3 | 16.9 | REHAU T-Stück FASTLOC EX+ 16 - 20 - 16 | 4067936345182 | 13706731001 | 203 | Domestic Cold Water 258
961153 | yes | no | 15 | 20 | 15 | 11.5 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000524178 | 19 | 26.8 | 19 | REHAU T-Stück FASTLOC EX+ 20 - 25 - 20 | 4067936344833 | 13707781001 | 111 | Domestic Cold Water 261

# IfcFlowFitting: RAUTITAN_Sleeve PX:RTI S PX (16)
In: Level 1
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: RTI S PX
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Sleeve PX:RTI S PX; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX; Family and Type: RAUTITAN_Sleeve PX: RTI S PX; Type: RTI S PX; Type Id: 874505
Constraints - Level: Level 1; Elevation from Level: 13.7 mm; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX:RTI S PX:...) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
874574 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
874578 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
874583 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
874589 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
907014 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
907016 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
907018 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
907020 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
961307 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
961309 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
961311 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
961313 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
962053 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
962055 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
962057 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
962059 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828

# IfcFlowSegment: Pipe Types:FASTLOC EX+ ML AT bar (134)
In: Level 1
Type - Other - Category: Pipes; Family Name: Pipe Types
