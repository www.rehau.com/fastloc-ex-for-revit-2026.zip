Properties of the parts of a building model (IFC4), part 4 of 4

# IfcPipeSegment: Pipe Types:FASTLOC EX+ ML AT coil (133)
Name (Pipe Types:FASTLOC EX+ ML AT coil:...) | InvertElevation (mm) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
962179 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 186
962181 | -8 | 162.373 | 0.000314112 | 0.0102022 | Domestic Cold Water 183
962183 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 180
962185 | -6 | 209.67 | 0.000201032 | 0.0105392 | Domestic Cold Water 177
962187 | -6 | 174.217 | 0.000201032 | 0.00875708 | Domestic Cold Water 175
962189 | -6 | 140 | 0.000201032 | 0.00703717 | Domestic Cold Water 316
962191 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 316
962193 | -8 | 160 | 0.000314112 | 0.0100531 | Domestic Cold Water 318
962195 | -8 | 179.8 | 0.000314112 | 0.0112972 | Domestic Cold Water 318
962197 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 320
962199 | -10 | 160 | 0.0004908 | 0.0125664 | Domestic Cold Water 320
962201 | -13 | 178 | 0.000804127 | 0.0178945 | Domestic Cold Water 322
962203 | -13 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 322
962205 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 173
962207 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 173
962209 | -8 | 135 | 0.000314112 | 0.0084823 | Domestic Cold Water 171
962211 | -8 | 170 | 0.000314112 | 0.0106814 | Domestic Cold Water 171
962213 | -6 | 100 | 0.000201032 | 0.00502655 | Domestic Cold Water 167
962215 | -6 | 170 | 0.000201032 | 0.00854513 | Domestic Cold Water 167
962217 | -6 | 115.34 | 0.000201032 | 0.00579762 | Domestic Cold Water 330
962219 | -6 | 120 | 0.000201032 | 0.00603186 | Domestic Cold Water 330
962221 | -8 | 100 | 0.000314112 | 0.00628319 | Domestic Cold Water 330
962223 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 333
962225 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 333
962227 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 333
962229 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 336
962231 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 336
962233 | -6 | 65 | 0.000201032 | 0.00326726 | Domestic Cold Water 336
962235 | -6 | 51.7891 | 0.000201032 | 0.00260321 | Domestic Cold Water 339
962237 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 339
962239 | -6 | 57.2789 | 0.000201032 | 0.00287915 | Domestic Cold Water 339
962241 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 342
962243 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 342
962245 | -10 | 95 | 0.0004908 | 0.00746128 | Domestic Cold Water 342
962247 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 345
962249 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 345
962251 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 345
962253 | -10 | 70.4 | 0.0004908 | 0.0055292 | Domestic Cold Water 348
962255 | -10 | 85 | 0.0004908 | 0.00667588 | Domestic Cold Water 348
962257 | -13 | 185 | 0.000804127 | 0.0185982 | Domestic Cold Water 348
962259 | -6 | 55 | 0.000201032 | 0.0027646 | Domestic Cold Water 351
962261 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 351
962263 | -8 | 130 | 0.000314112 | 0.00816814 | Domestic Cold Water 351
962265 | -8 | 55 | 0.000314112 | 0.00345575 | Domestic Cold Water 354
962267 | -6 | 70 | 0.000201032 | 0.00351858 | Domestic Cold Water 354
962269 | -8 | 110 | 0.000314112 | 0.0069115 | Domestic Cold Water 354
962271 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 357
962273 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 357
962275 | -10 | 135 | 0.0004908 | 0.0106029 | Domestic Cold Water 357
962277 | -13 | 90 | 0.000804127 | 0.00904779 | Domestic Cold Water 360
962279 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 360
962281 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 360
962283 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 363
962285 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 363
962287 | -13 | 165 | 0.000804127 | 0.0165876 | Domestic Cold Water 363
962289 | -13 | 134.6 | 0.000804127 | 0.0135315 | Domestic Cold Water 366
962291 | -13 | 169.6 | 0.000804127 | 0.0170501 | Domestic Cold Water 366
962293 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 366
962295 | -13 | 132.8 | 0.000804127 | 0.0133505 | Domestic Cold Water 369
962297 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 369
962299 | -10 | 120 | 0.0004908 | 0.00942478 | Domestic Cold Water 369
962301 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 372
962303 | -13 | 135 | 0.000804127 | 0.0135717 | Domestic Cold Water 372
962305 | -13 | 115 | 0.000804127 | 0.0115611 | Domestic Cold Water 372
962307 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 375
962309 | -10 | 105 | 0.0004908 | 0.00824668 | Domestic Cold Water 375
962311 | -10 | 165 | 0.0004908 | 0.0129591 | Domestic Cold Water 375
962313 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 378
962315 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 378
962317 | -8 | 85 | 0.000314112 | 0.00534071 | Domestic Cold Water 378
962319 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 381
962321 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 381
962323 | -6 | 95 | 0.000201032 | 0.00477522 | Domestic Cold Water 381
962325 | -13 | 212.786 | 0.000804127 | 0.0213916 | Domestic Cold Water 189
962331 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 385
962333 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 385
962335 | -8 | 240.6 | 0.000314112 | 0.0151173 | Domestic Cold Water 387
962337 | -10 | 218.9 | 0.0004908 | 0.0171924 | Domestic Cold Water 387
962339 | -10 | 240.5 | 0.0004908 | 0.0188888 | Domestic Cold Water 389
962341 | -13 | 216.3 | 0.000804127 | 0.0217448 | Domestic Cold Water 389

# IfcPipeSegment: Pipe Types:FASTLOC EX+ ML DE bar (132)
In: Level 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC EX+ ML DE bar; sets with these values: 2
Name (Pipe Types:FASTLOC EX+ ML DE bar:...) | InvertElevation (mm) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
885852 | -6 | 160 | 0.000201032 | 0.00804248 | Domestic Cold Water 1
885870 | -6 | 192 | 0.000201032 | 0.00965097 | Domestic Cold Water 1
885887 | -8 | 180 | 0.000314112 | 0.0113097 | Domestic Cold Water 2
885905 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 2
885922 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 3
885942 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 3
885964 | -13 | 200 | 0.000804127 | 0.0201062 | Domestic Cold Water 4
885982 | -13 | 184 | 0.000804127 | 0.0184977 | Domestic Cold Water 4
885997 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 5
886013 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 5
886033 | 3.7 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 6
886053 | 3.7 | 182.7 | 0.0004908 | 0.0143492 | Domestic Cold Water 6
886070 | 5.7 | 120 | 0.000314112 | 0.00753982 | Domestic Cold Water 7
886086 | 5.7 | 240.3 | 0.000314112 | 0.0150985 | Domestic Cold Water 7
886107 | 7.7 | 120.6 | 0.000201032 | 0.00606202 | Domestic Cold Water 8
886123 | 7.7 | 200 | 0.000201032 | 0.0100531 | Domestic Cold Water 8
886138 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 66
886157 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 67
886176 | -6 | 130 | 0.000201032 | 0.00653451 | Domestic Cold Water 63
886195 | -6 | 190 | 0.000201032 | 0.00955044 | Domestic Cold Water 64
886216 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 65
886235 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 61
886252 | -8 | 221 | 0.000314112 | 0.0138858 | Domestic Cold Water 60
886272 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 59
886293 | -6 | 240.4 | 0.000201032 | 0.0120838 | Domestic Cold Water 58
886310 | -6 | 220 | 0.000201032 | 0.0110584 | Domestic Cold Water 9
886332 | -8 | 219.6 | 0.000314112 | 0.0137979 | Domestic Cold Water 10
886348 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 11
886368 | -10 | 250 | 0.0004908 | 0.019635 | Domestic Cold Water 12
886388 | -13 | 230 | 0.000804127 | 0.0231221 | Domestic Cold Water 14
886408 | -13 | 280 | 0.000804127 | 0.0281487 | Domestic Cold Water 62
886425 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 15
886443 | -8 | 237.5 | 0.000314112 | 0.0149226 | Domestic Cold Water 17
886463 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 17
886480 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 15
886497 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 18
886515 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 18
886530 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 20
886550 | -13 | 227.1 | 0.000804127 | 0.0228306 | Domestic Cold Water 20
886567 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 48
886605 | -10 | 202.5 | 0.0004908 | 0.0159043 | Domestic Cold Water 47
886622 | -8 | 223.9 | 0.000314112 | 0.0140681 | Domestic Cold Water 46
886648 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 45
886665 | -6 | 150 | 0.000201032 | 0.00753982 | Domestic Cold Water 41
886686 | -8 | 150 | 0.000314112 | 0.00942478 | Domestic Cold Water 42
886703 | -10 | 148.7 | 0.0004908 | 0.0116789 | Domestic Cold Water 43
886722 | -13 | 147.5 | 0.000804127 | 0.0148283 | Domestic Cold Water 44
886737 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 36
886754 | -8 | 180.7 | 0.000314112 | 0.0113537 | Domestic Cold Water 37
886775 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 38
886792 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 39
886809 | -13 | 218.4 | 0.000804127 | 0.021956 | Domestic Cold Water 40
886826 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 34
886845 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 33
886864 | -8 | 162.373 | 0.000314112 | 0.0102022 | Domestic Cold Water 32
886883 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 31
886900 | -6 | 209.67 | 0.000201032 | 0.0105392 | Domestic Cold Water 30
886915 | -6 | 174.217 | 0.000201032 | 0.00875708 | Domestic Cold Water 29
886932 | -6 | 140 | 0.000201032 | 0.00703717 | Domestic Cold Water 21
886948 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 21
886963 | -8 | 160 | 0.000314112 | 0.0100531 | Domestic Cold Water 22
886979 | -8 | 179.8 | 0.000314112 | 0.0112972 | Domestic Cold Water 22
887000 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 23
887016 | -10 | 160 | 0.0004908 | 0.0125664 | Domestic Cold Water 23
887031 | -13 | 178 | 0.000804127 | 0.0178945 | Domestic Cold Water 24
887047 | -13 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 24
887075 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 19
887096 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 19
887117 | -8 | 135 | 0.000314112 | 0.0084823 | Domestic Cold Water 16
887134 | -8 | 170 | 0.000314112 | 0.0106814 | Domestic Cold Water 16
887151 | -6 | 100 | 0.000201032 | 0.00502655 | Domestic Cold Water 13
887166 | -6 | 170 | 0.000201032 | 0.00854513 | Domestic Cold Water 13
887185 | -6 | 115.34 | 0.000201032 | 0.00579762 | Domestic Cold Water 25
887203 | -6 | 120 | 0.000201032 | 0.00603186 | Domestic Cold Water 25
887222 | -8 | 100 | 0.000314112 | 0.00628319 | Domestic Cold Water 25
887304 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 26
887328 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 26
887345 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 26
887389 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 27
887407 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 27
887426 | -6 | 65 | 0.000201032 | 0.00326726 | Domestic Cold Water 27
887443 | -6 | 51.7891 | 0.000201032 | 0.00260321 | Domestic Cold Water 28
887461 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 28
887482 | -6 | 57.2789 | 0.000201032 | 0.00287915 | Domestic Cold Water 28
887499 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 49
887519 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 49
887536 | -10 | 95 | 0.0004908 | 0.00746128 | Domestic Cold Water 49
887555 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 50
887573 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 50
887590 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 50
887609 | -10 | 70.4 | 0.0004908 | 0.0055292 | Domestic Cold Water 51
887629 | -10 | 85 | 0.0004908 | 0.00667588 | Domestic Cold Water 51
887648 | -13 | 185 | 0.000804127 | 0.0185982 | Domestic Cold Water 51
887665 | -6 | 55 | 0.000201032 | 0.0027646 | Domestic Cold Water 52
887685 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 52
887704 | -8 | 130 | 0.000314112 | 0.00816814 | Domestic Cold Water 52
887721 | -8 | 55 | 0.000314112 | 0.00345575 | Domestic Cold Water 53
887739 | -6 | 70 | 0.000201032 | 0.00351858 | Domestic Cold Water 53
887756 | -8 | 110 | 0.000314112 | 0.0069115 | Domestic Cold Water 53
887775 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 54
887793 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 54
887810 | -10 | 135 | 0.0004908 | 0.0106029 | Domestic Cold Water 54
887831 | -13 | 90 | 0.000804127 | 0.00904779 | Domestic Cold Water 55
887858 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 55
887875 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 55
887892 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 56
887912 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 56
887929 | -13 | 165 | 0.000804127 | 0.0165876 | Domestic Cold Water 56
887948 | -13 | 134.6 | 0.000804127 | 0.0135315 | Domestic Cold Water 57
887968 | -13 | 169.6 | 0.000804127 | 0.0170501 | Domestic Cold Water 57
887987 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 57
888004 | -13 | 132.8 | 0.000804127 | 0.0133505 | Domestic Cold Water 68
888024 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 68
888039 | -10 | 120 | 0.0004908 | 0.00942478 | Domestic Cold Water 68
888056 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 69
888074 | -13 | 135 | 0.000804127 | 0.0135717 | Domestic Cold Water 69
888098 | -13 | 115 | 0.000804127 | 0.0115611 | Domestic Cold Water 69
888115 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 70
888135 | -10 | 105 | 0.0004908 | 0.00824668 | Domestic Cold Water 70
888156 | -10 | 165 | 0.0004908 | 0.0129591 | Domestic Cold Water 70
888173 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 71
888189 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 71
888206 | -8 | 85 | 0.000314112 | 0.00534071 | Domestic Cold Water 71
888247 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 72
888266 | -6 | 95 | 0.000201032 | 0.00477522 | Domestic Cold Water 72
888284 | -13 | 212.786 | 0.000804127 | 0.0213916 | Domestic Cold Water 35
963162 | -6 | 220 | 0.000201032 | 0.0110584 | Domestic Cold Water 237
963182 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 237
963201 | -8 | 220.6 | 0.000314112 | 0.0138607 | Domestic Cold Water 239
963221 | -10 | 198.9 | 0.0004908 | 0.0156216 | Domestic Cold Water 239
963242 | -10 | 220.5 | 0.0004908 | 0.017318 | Domestic Cold Water 241
963262 | -13 | 196.3 | 0.000804127 | 0.0197342 | Domestic Cold Water 241

# IfcPipeSegment: Pipe Types:FASTLOC EX+ ML DE coil (133)
In: Level 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC EX+ ML DE coil; sets with these values: 2
Name (Pipe Types:FASTLOC EX+ ML DE coil:...) | InvertElevation (mm) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
961319 | -6 | 160 | 0.000201032 | 0.00804248 | Domestic Cold Water 165
961321 | -6 | 192 | 0.000201032 | 0.00965097 | Domestic Cold Water 165
961325 | -8 | 180 | 0.000314112 | 0.0113097 | Domestic Cold Water 169
961327 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 169
961331 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 172
961333 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 172
961337 | -13 | 200 | 0.000804127 | 0.0201062 | Domestic Cold Water 174
961339 | -13 | 184 | 0.000804127 | 0.0184977 | Domestic Cold Water 174
961343 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 176
961345 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 176
961347 | 3.7 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 179
961349 | 3.7 | 182.7 | 0.0004908 | 0.0143492 | Domestic Cold Water 179
961351 | 5.7 | 120 | 0.000314112 | 0.00753982 | Domestic Cold Water 182
961353 | 5.7 | 240.3 | 0.000314112 | 0.0150985 | Domestic Cold Water 182
961355 | 7.7 | 120.6 | 0.000201032 | 0.00606202 | Domestic Cold Water 185
961357 | 7.7 | 200 | 0.000201032 | 0.0100531 | Domestic Cold Water 185
961359 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 162
961361 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 163
961363 | -6 | 130 | 0.000201032 | 0.00653451 | Domestic Cold Water 159
961365 | -6 | 190 | 0.000201032 | 0.00955044 | Domestic Cold Water 160
961367 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 161
961369 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 157
961371 | -8 | 221 | 0.000314112 | 0.0138858 | Domestic Cold Water 156
961373 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 155
961375 | -6 | 240.4 | 0.000201032 | 0.0120838 | Domestic Cold Water 154
961377 | -6 | 220 | 0.000201032 | 0.0110584 | Domestic Cold Water 149
961379 | -8 | 219.6 | 0.000314112 | 0.0137979 | Domestic Cold Water 150
961381 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 151
961383 | -10 | 250 | 0.0004908 | 0.019635 | Domestic Cold Water 152
961385 | -13 | 230 | 0.000804127 | 0.0231221 | Domestic Cold Water 153
961387 | -13 | 280 | 0.000804127 | 0.0281487 | Domestic Cold Water 158
961389 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 210
961391 | -8 | 237.5 | 0.000314112 | 0.0149226 | Domestic Cold Water 212
961393 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 212
961395 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 210
961397 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 216
961399 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 216
961401 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 219
961403 | -13 | 227.1 | 0.000804127 | 0.0228306 | Domestic Cold Water 219
961405 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 148
961407 | -10 | 202.5 | 0.0004908 | 0.0159043 | Domestic Cold Water 147
961409 | -8 | 223.9 | 0.000314112 | 0.0140681 | Domestic Cold Water 146
961411 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 145
961413 | -6 | 150 | 0.000201032 | 0.00753982 | Domestic Cold Water 139
961415 | -8 | 150 | 0.000314112 | 0.00942478 | Domestic Cold Water 140
961417 | -10 | 148.7 | 0.0004908 | 0.0116789 | Domestic Cold Water 142
961419 | -13 | 147.5 | 0.000804127 | 0.0148283 | Domestic Cold Water 144
961421 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 127
961423 | -8 | 180.7 | 0.000314112 | 0.0113537 | Domestic Cold Water 128
961425 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 129
961427 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 130
961429 | -13 | 218.4 | 0.000804127 | 0.021956 | Domestic Cold Water 136
961431 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 125
961433 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 124
961435 | -8 | 162.373 | 0.000314112 | 0.0102022 | Domestic Cold Water 123
961437 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 122
961439 | -6 | 209.67 | 0.000201032 | 0.0105392 | Domestic Cold Water 121
961441 | -6 | 174.217 | 0.000201032 | 0.00875708 | Domestic Cold Water 119
961443 | -6 | 140 | 0.000201032 | 0.00703717 | Domestic Cold Water 244
961445 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 244
961447 | -8 | 160 | 0.000314112 | 0.0100531 | Domestic Cold Water 246
961449 | -8 | 179.8 | 0.000314112 | 0.0112972 | Domestic Cold Water 246
961451 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 248
961453 | -10 | 160 | 0.0004908 | 0.0125664 | Domestic Cold Water 248
961455 | -13 | 178 | 0.000804127 | 0.0178945 | Domestic Cold Water 250
961457 | -13 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 250
961459 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 117
961461 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 117
961463 | -8 | 135 | 0.000314112 | 0.0084823 | Domestic Cold Water 115
961465 | -8 | 170 | 0.000314112 | 0.0106814 | Domestic Cold Water 115
961467 | -6 | 100 | 0.000201032 | 0.00502655 | Domestic Cold Water 113
961469 | -6 | 170 | 0.000201032 | 0.00854513 | Domestic Cold Water 113
961471 | -6 | 115.34 | 0.000201032 | 0.00579762 | Domestic Cold Water 258
961473 | -6 | 120 | 0.000201032 | 0.00603186 | Domestic Cold Water 258
961475 | -8 | 100 | 0.000314112 | 0.00628319 | Domestic Cold Water 258
961477 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 261
961479 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 261
961481 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 261
961483 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 264
961485 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 264
961487 | -6 | 65 | 0.000201032 | 0.00326726 | Domestic Cold Water 264
961489 | -6 | 51.7891 | 0.000201032 | 0.00260321 | Domestic Cold Water 267
961491 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 267
961493 | -6 | 57.2789 | 0.000201032 | 0.00287915 | Domestic Cold Water 267
961495 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 270
961497 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 270
961499 | -10 | 95 | 0.0004908 | 0.00746128 | Domestic Cold Water 270
961501 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 273
961503 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 273
961505 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 273
961507 | -10 | 70.4 | 0.0004908 | 0.0055292 | Domestic Cold Water 276
961509 | -10 | 85 | 0.0004908 | 0.00667588 | Domestic Cold Water 276
961511 | -13 | 185 | 0.000804127 | 0.0185982 | Domestic Cold Water 276
961513 | -6 | 55 | 0.000201032 | 0.0027646 | Domestic Cold Water 279
961515 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 279
961517 | -8 | 130 | 0.000314112 | 0.00816814 | Domestic Cold Water 279
961519 | -8 | 55 | 0.000314112 | 0.00345575 | Domestic Cold Water 282
961521 | -6 | 70 | 0.000201032 | 0.00351858 | Domestic Cold Water 282
961523 | -8 | 110 | 0.000314112 | 0.0069115 | Domestic Cold Water 282
961525 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 285
961527 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 285
961529 | -10 | 135 | 0.0004908 | 0.0106029 | Domestic Cold Water 285
961531 | -13 | 90 | 0.000804127 | 0.00904779 | Domestic Cold Water 288
961533 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 288
961535 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 288
961537 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 291
961539 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 291
961541 | -13 | 165 | 0.000804127 | 0.0165876 | Domestic Cold Water 291
961543 | -13 | 134.6 | 0.000804127 | 0.0135315 | Domestic Cold Water 294
961545 | -13 | 169.6 | 0.000804127 | 0.0170501 | Domestic Cold Water 294
961547 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 294
961549 | -13 | 132.8 | 0.000804127 | 0.0133505 | Domestic Cold Water 297
961551 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 297
961553 | -10 | 120 | 0.0004908 | 0.00942478 | Domestic Cold Water 297
961555 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 300
961557 | -13 | 135 | 0.000804127 | 0.0135717 | Domestic Cold Water 300
961559 | -13 | 115 | 0.000804127 | 0.0115611 | Domestic Cold Water 300
961561 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 303
961563 | -10 | 105 | 0.0004908 | 0.00824668 | Domestic Cold Water 303
961565 | -10 | 165 | 0.0004908 | 0.0129591 | Domestic Cold Water 303
961567 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 306
961569 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 306
961571 | -8 | 85 | 0.000314112 | 0.00534071 | Domestic Cold Water 306
961573 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 309
961575 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 309
961577 | -6 | 95 | 0.000201032 | 0.00477522 | Domestic Cold Water 309
961579 | -13 | 212.786 | 0.000804127 | 0.0213916 | Domestic Cold Water 126
963338 | -6 | 280 | 0.000201032 | 0.0140743 | Domestic Cold Water 243
963356 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 243
963376 | -8 | 280.6 | 0.000314112 | 0.0176306 | Domestic Cold Water 247
963396 | -10 | 198.9 | 0.0004908 | 0.0156216 | Domestic Cold Water 247
963413 | -10 | 280.5 | 0.0004908 | 0.0220304 | Domestic Cold Water 251
963431 | -13 | 196.3 | 0.000804127 | 0.0197342 | Domestic Cold Water 251
