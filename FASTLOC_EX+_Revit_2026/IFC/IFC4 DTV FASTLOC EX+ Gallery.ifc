Properties of the parts of a building model (IFC4), part 3 of 4

# IfcDistributionPort (1764)
Name | FlowDirection | SystemType | Group
Port_962028_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 232
Port_962030_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 233
Port_962113_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 233
Port_962030_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 233
Port_962035_3 | SOURCEANDSINK
Port_962035_4 | SOURCEANDSINK
Port_962035_5 | SOURCEANDSINK
Port_962037_3 | SOURCEANDSINK
Port_962037_4 | SOURCEANDSINK
Port_962037_5 | SOURCEANDSINK
InPort_962039_1 | SINK | DOMESTICCOLDWATER | Domestic Cold Water 234
OutPort_962105_0 | SOURCE | DOMESTICCOLDWATER | Domestic Cold Water 234
InPort_962041_1 | SINK | DOMESTICCOLDWATER | Domestic Cold Water 235
OutPort_962107_0 | SOURCE | DOMESTICCOLDWATER | Domestic Cold Water 235
Port_962045_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
Port_962103_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
Port_962045_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
Port_962101_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
Port_962047_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962099_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962047_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962097_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962049_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962093_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962049_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962095_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962051_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962091_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962051_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962089_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962065_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962069_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962065_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962067_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962069_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962067_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 236
Port_962071_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962075_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962071_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962073_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962075_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962073_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 238
Port_962077_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962081_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962077_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962079_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962081_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962079_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 240
Port_962083_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962087_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962083_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962085_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962087_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962085_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 242
Port_962089_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962091_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 245
Port_962093_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962095_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 249
Port_962097_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962099_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 252
Port_962101_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
Port_962103_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 254
InPort_962105_1 | SINK | DOMESTICCOLDWATER | Domestic Cold Water 234
InPort_962107_1 | SINK | DOMESTICCOLDWATER | Domestic Cold Water 235
Port_962109_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 231
Port_962111_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 232
Port_962113_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 233
Port_962115_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 228
Port_962117_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 227
Port_962119_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 225
Port_962121_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 224
Port_962123_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 213
Port_962125_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 215
Port_962127_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 218
Port_962129_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 221
Port_962131_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 222
Port_962133_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 230
Port_962135_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 278
Port_962137_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 280
Port_962139_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 280
Port_962141_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 278
Port_962143_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 284
Port_962145_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 284
Port_962147_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 287
Port_962149_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 287
Port_962151_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 209
Port_962153_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 207
Port_962155_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 206
Port_962157_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 204
Port_962159_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 198
Port_962161_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 200
Port_962163_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 201
Port_962165_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 203
Port_962167_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 191
Port_962169_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 192
Port_962171_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 194
Port_962173_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 195
Port_962175_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 197
Port_962177_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 188
Port_962179_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 186
Port_962181_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 183
Port_962183_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 180
Port_962185_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 177
Port_962187_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 175
Port_962189_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 316
Port_962191_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 316
Port_962193_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 318
Port_962195_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 318
Port_962197_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 320
Port_962199_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 320
Port_962201_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 322
Port_962203_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 322
Port_962205_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 173
Port_962207_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 173
Port_962209_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 171
Port_962211_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 171
Port_962213_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 167
Port_962215_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 167
Port_962217_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 330
Port_962219_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 330
Port_962221_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 330
Port_962223_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 333
Port_962225_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 333
Port_962227_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 333
Port_962229_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 336
Port_962231_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 336
Port_962233_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 336
Port_962235_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 339
Port_962237_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 339
Port_962239_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 339
Port_962241_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 342
Port_962243_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 342
Port_962245_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 342
Port_962247_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 345
Port_962249_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 345
Port_962251_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 345
Port_962253_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 348
Port_962255_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 348
Port_962257_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 348
Port_962259_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 351
Port_962261_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 351
Port_962263_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 351
Port_962265_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 354
Port_962267_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 354
Port_962269_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 354
Port_962271_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 357
Port_962273_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 357
Port_962275_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 357
Port_962277_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 360
Port_962279_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 360
Port_962281_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 360
Port_962283_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 363
Port_962285_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 363
Port_962287_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 363
Port_962289_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 366
Port_962291_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 366
Port_962293_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 366
Port_962295_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 369
Port_962297_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 369
Port_962299_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 369
Port_962301_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 372
Port_962303_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 372
Port_962305_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 372
Port_962307_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 375
Port_962309_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 375
Port_962311_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 375
Port_962313_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 378
Port_962315_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 378
Port_962317_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 378
Port_962319_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 381
Port_962321_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 381
Port_962323_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 381
Port_962325_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 189
Port_962331_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 385
Port_962333_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 385
Port_962335_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 387
Port_962337_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 387
Port_962339_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 389
Port_962341_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 389
Port_963162_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 237
Port_963182_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 237
Port_963201_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 239
Port_963221_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 239
Port_963242_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 241
Port_963262_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 241
Port_963338_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 243
Port_963356_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 243
Port_963376_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 247
Port_963396_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 247
Port_963413_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 251
Port_963431_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Domestic Cold Water 251

# IfcDistributionSystem: Domestic Cold Water (300)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Domestic Cold Water
Name
Domestic Cold Water 72
Domestic Cold Water 71
Domestic Cold Water 70
Domestic Cold Water 69
Domestic Cold Water 53
Domestic Cold Water 54
Domestic Cold Water 55
Domestic Cold Water 56
Domestic Cold Water 57
Domestic Cold Water 68
Domestic Cold Water 52
Domestic Cold Water 27
Domestic Cold Water 51
Domestic Cold Water 28
Domestic Cold Water 49
Domestic Cold Water 50
Domestic Cold Water 25
Domestic Cold Water 26
Domestic Cold Water 13
Domestic Cold Water 16
Domestic Cold Water 19
Domestic Cold Water 21
Domestic Cold Water 22
Domestic Cold Water 23
Domestic Cold Water 24
Domestic Cold Water 237
Domestic Cold Water 239
Domestic Cold Water 241
Domestic Cold Water 29
Domestic Cold Water 30
Domestic Cold Water 31
Domestic Cold Water 32
Domestic Cold Water 33
Domestic Cold Water 34
Domestic Cold Water 35
Domestic Cold Water 36
Domestic Cold Water 37
Domestic Cold Water 38
Domestic Cold Water 39
Domestic Cold Water 40
Domestic Cold Water 41
Domestic Cold Water 42
Domestic Cold Water 43
Domestic Cold Water 44
Domestic Cold Water 45
Domestic Cold Water 46
Domestic Cold Water 47
Domestic Cold Water 48
Domestic Cold Water 15
Domestic Cold Water 17
Domestic Cold Water 18
Domestic Cold Water 20
Domestic Cold Water 9
Domestic Cold Water 10
Domestic Cold Water 11
Domestic Cold Water 12
Domestic Cold Water 14
Domestic Cold Water 58
Domestic Cold Water 59
Domestic Cold Water 60
Domestic Cold Water 61
Domestic Cold Water 62
Domestic Cold Water 63
Domestic Cold Water 64
Domestic Cold Water 65
Domestic Cold Water 66
Domestic Cold Water 67
Domestic Cold Water 8
Domestic Cold Water 7
Domestic Cold Water 6
Domestic Cold Water 5
Domestic Cold Water 1
Domestic Cold Water 2
Domestic Cold Water 3
Domestic Cold Water 4
Domestic Cold Water 229
Domestic Cold Water 226
Domestic Cold Water 223
Domestic Cold Water 220
Domestic Cold Water 202
Domestic Cold Water 205
Domestic Cold Water 208
Domestic Cold Water 211
Domestic Cold Water 214
Domestic Cold Water 217
Domestic Cold Water 199
Domestic Cold Water 184
Domestic Cold Water 196
Domestic Cold Water 187
Domestic Cold Water 190
Domestic Cold Water 193
Domestic Cold Water 178
Domestic Cold Water 181
Domestic Cold Water 73
Domestic Cold Water 74
Domestic Cold Water 75
Domestic Cold Water 164
Domestic Cold Water 166
Domestic Cold Water 168
Domestic Cold Water 170
Domestic Cold Water 107
Domestic Cold Water 109
Domestic Cold Water 111
Domestic Cold Water 76
Domestic Cold Water 77
Domestic Cold Water 78
Domestic Cold Water 79
Domestic Cold Water 80
Domestic Cold Water 81
Domestic Cold Water 82
Domestic Cold Water 83
Domestic Cold Water 84
Domestic Cold Water 85
Domestic Cold Water 86
Domestic Cold Water 87
Domestic Cold Water 88
Domestic Cold Water 89
Domestic Cold Water 90
Domestic Cold Water 91
Domestic Cold Water 92
Domestic Cold Water 93
Domestic Cold Water 94
Domestic Cold Water 95
Domestic Cold Water 137
Domestic Cold Water 138
Domestic Cold Water 141
Domestic Cold Water 143
Domestic Cold Water 131
Domestic Cold Water 132
Domestic Cold Water 133
Domestic Cold Water 134
Domestic Cold Water 135
Domestic Cold Water 96
Domestic Cold Water 97
Domestic Cold Water 98
Domestic Cold Water 99
Domestic Cold Water 100
Domestic Cold Water 101
Domestic Cold Water 102
Domestic Cold Water 103
Domestic Cold Water 104
Domestic Cold Water 105
Domestic Cold Water 120
Domestic Cold Water 118
Domestic Cold Water 116
Domestic Cold Water 114
Domestic Cold Water 106
Domestic Cold Water 108
Domestic Cold Water 110
Domestic Cold Water 112
Domestic Cold Water 309
Domestic Cold Water 306
Domestic Cold Water 303
Domestic Cold Water 300
Domestic Cold Water 282
Domestic Cold Water 285
Domestic Cold Water 288
Domestic Cold Water 291
Domestic Cold Water 294
Domestic Cold Water 297
Domestic Cold Water 279
Domestic Cold Water 264
Domestic Cold Water 276
Domestic Cold Water 267
Domestic Cold Water 270
Domestic Cold Water 273
Domestic Cold Water 258
Domestic Cold Water 261
Domestic Cold Water 113
Domestic Cold Water 115
Domestic Cold Water 117
Domestic Cold Water 244
Domestic Cold Water 246
Domestic Cold Water 248
Domestic Cold Water 250
Domestic Cold Water 243
Domestic Cold Water 247
Domestic Cold Water 251
Domestic Cold Water 119
Domestic Cold Water 121
Domestic Cold Water 122
Domestic Cold Water 123
Domestic Cold Water 124
Domestic Cold Water 125
Domestic Cold Water 126
Domestic Cold Water 127
Domestic Cold Water 128
Domestic Cold Water 129
Domestic Cold Water 130
Domestic Cold Water 136
Domestic Cold Water 139
Domestic Cold Water 140
Domestic Cold Water 142
Domestic Cold Water 144
Domestic Cold Water 145
Domestic Cold Water 146
Domestic Cold Water 147
Domestic Cold Water 148
Domestic Cold Water 210
Domestic Cold Water 212
Domestic Cold Water 216
Domestic Cold Water 219
Domestic Cold Water 149
Domestic Cold Water 150
Domestic Cold Water 151
Domestic Cold Water 152
Domestic Cold Water 153
Domestic Cold Water 154
Domestic Cold Water 155
Domestic Cold Water 156
Domestic Cold Water 157
Domestic Cold Water 158
Domestic Cold Water 159
Domestic Cold Water 160
Domestic Cold Water 161
Domestic Cold Water 162
Domestic Cold Water 163
Domestic Cold Water 185
Domestic Cold Water 182
Domestic Cold Water 179
Domestic Cold Water 176
Domestic Cold Water 165
Domestic Cold Water 169
Domestic Cold Water 172
Domestic Cold Water 174
Domestic Cold Water 381
Domestic Cold Water 378
Domestic Cold Water 375
Domestic Cold Water 372
Domestic Cold Water 354
Domestic Cold Water 357
Domestic Cold Water 360
Domestic Cold Water 363
Domestic Cold Water 366
Domestic Cold Water 369
Domestic Cold Water 351
Domestic Cold Water 336
Domestic Cold Water 348
Domestic Cold Water 339
Domestic Cold Water 342
Domestic Cold Water 345
Domestic Cold Water 330
Domestic Cold Water 333
Domestic Cold Water 167
Domestic Cold Water 171
Domestic Cold Water 173
Domestic Cold Water 316
Domestic Cold Water 318
Domestic Cold Water 320
Domestic Cold Water 322
Domestic Cold Water 385
Domestic Cold Water 387
Domestic Cold Water 389
Domestic Cold Water 175
Domestic Cold Water 177
Domestic Cold Water 180
Domestic Cold Water 183
Domestic Cold Water 186
Domestic Cold Water 188
Domestic Cold Water 189
Domestic Cold Water 191
Domestic Cold Water 192
Domestic Cold Water 194
Domestic Cold Water 195
Domestic Cold Water 197
Domestic Cold Water 198
Domestic Cold Water 200
Domestic Cold Water 201
Domestic Cold Water 203
Domestic Cold Water 204
Domestic Cold Water 206
Domestic Cold Water 207
Domestic Cold Water 209
Domestic Cold Water 278
Domestic Cold Water 280
Domestic Cold Water 284
Domestic Cold Water 287
Domestic Cold Water 213
Domestic Cold Water 215
Domestic Cold Water 218
Domestic Cold Water 221
Domestic Cold Water 222
Domestic Cold Water 224
Domestic Cold Water 225
Domestic Cold Water 227
Domestic Cold Water 228
Domestic Cold Water 230
Domestic Cold Water 231
Domestic Cold Water 232
Domestic Cold Water 233
Domestic Cold Water 234
Domestic Cold Water 235
Domestic Cold Water 254
Domestic Cold Water 252
Domestic Cold Water 249
Domestic Cold Water 245
Domestic Cold Water 236
Domestic Cold Water 238
Domestic Cold Water 240
Domestic Cold Water 242

# IfcPipeFitting: FASTLOC Copper press adapter RX+:FSL RX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL RX+ AT; sets with these values: 2
Name (FASTLOC Copper press adapter RX+:FSL RX+ AT:...) | Group
906929 | Domestic Cold Water 92
906931 | Domestic Cold Water 93
906933 | Domestic Cold Water 94
906935 | Domestic Cold Water 95
961972 | Domestic Cold Water 204
961974 | Domestic Cold Water 206
961976 | Domestic Cold Water 207
961978 | Domestic Cold Water 209

# IfcPipeFitting: FASTLOC Copper press adapter RX+:FSL RX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL RX+ DE; sets with these values: 2
Name (FASTLOC Copper press adapter RX+:FSL RX+ DE:...) | Group
839516 | Domestic Cold Water 45
839614 | Domestic Cold Water 46
839906 | Domestic Cold Water 47
839986 | Domestic Cold Water 48
961226 | Domestic Cold Water 145
961228 | Domestic Cold Water 146
961230 | Domestic Cold Water 147
961232 | Domestic Cold Water 148

# IfcPipeFitting: FASTLOC_ Backplate elbow short EX+:FSL Backplate elbow DE (6)
In: Level 1
Type - Material: lead-free gunmetal according to DIN SPEC 2701, Polyvinyl Difluoride
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL Backplate elbow DE; sets with these values: 2
Name (FASTLOC_ Backplate elbow short EX+:FSL Backplate elbow DE:...) | Group
861263 | Domestic Cold Water 63
861385 | Domestic Cold Water 64
861445 | Domestic Cold Water 65
961280 | Domestic Cold Water 159
961282 | Domestic Cold Water 160
961284 | Domestic Cold Water 161

# IfcPipeFitting: FASTLOC_Adapter coupling EX+:FSL TC EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL TC EX+ AT; sets with these values: 2
Name (FASTLOC_Adapter coupling EX+:FSL TC EX+ AT:...) | Group
907006 | Domestic Cold Water 120
907008 | Domestic Cold Water 118
907010 | Domestic Cold Water 116
907012 | Domestic Cold Water 114
962045 | Domestic Cold Water 254
962047 | Domestic Cold Water 252
962049 | Domestic Cold Water 249
962051 | Domestic Cold Water 245

# IfcPipeFitting: FASTLOC_Adapter coupling EX+:FSL TC EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL TC EX+ DE; sets with these values: 2
Name (FASTLOC_Adapter coupling EX+:FSL TC EX+ DE:...) | Group
869692 | Domestic Cold Water 8
869893 | Domestic Cold Water 7
870124 | Domestic Cold Water 6
870275 | Domestic Cold Water 5
961299 | Domestic Cold Water 185
961301 | Domestic Cold Water 182
961303 | Domestic Cold Water 179
961305 | Domestic Cold Water 176

# IfcPipeFitting: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A union nut EX+ AT; sets with these values: 2
Name (FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ AT:...) | Group
906919 | Domestic Cold Water 89
906921 | Domestic Cold Water 90
961960 | Domestic Cold Water 198
961962 | Domestic Cold Water 200
961964 | Domestic Cold Water 201
961966 | Domestic Cold Water 203

# IfcPipeFitting: FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A union nut EX+ DE; sets with these values: 2
Name (FASTLOC_Adapter with union nut EX+:FSL A union nut EX+ DE:...) | Group
835853 | Domestic Cold Water 41
835865 | Domestic Cold Water 42
835877 | Domestic Cold Water 43
835889 | Domestic Cold Water 44
906917 | Domestic Cold Water 88
906923 | Domestic Cold Water 91
961214 | Domestic Cold Water 139
961216 | Domestic Cold Water 140
961218 | Domestic Cold Water 142
961220 | Domestic Cold Water 144

# IfcPipeFitting: FASTLOC_Adapter_EX+, with internal thread:FSL A internal AT (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal AT; sets with these values: 2
Name (FASTLOC_Adapter_EX+, with internal thread:FSL A internal AT:...) | Group
906902 | Domestic Cold Water 83
906904 | Domestic Cold Water 84
906906 | Domestic Cold Water 85
906908 | Domestic Cold Water 86
906910 | Domestic Cold Water 87
961945 | Domestic Cold Water 191
961947 | Domestic Cold Water 192
961949 | Domestic Cold Water 194
961951 | Domestic Cold Water 195
961953 | Domestic Cold Water 197

# IfcPipeFitting: FASTLOC_Adapter_EX+, with internal thread:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal DE; sets with these values: 2
Name (FASTLOC_Adapter_EX+, with internal thread:FSL A internal DE:...) | Group
830264 | Domestic Cold Water 36
830276 | Domestic Cold Water 37
830288 | Domestic Cold Water 38
830300 | Domestic Cold Water 39
830312 | Domestic Cold Water 40
961199 | Domestic Cold Water 127
961201 | Domestic Cold Water 128
961203 | Domestic Cold Water 129
961205 | Domestic Cold Water 130
961207 | Domestic Cold Water 136

# IfcPipeFitting: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ AT (14)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A C external EX+ AT; sets with these values: 2
Name (FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ AT:...) | Group
906888 | Domestic Cold Water 76
906890 | Domestic Cold Water 77
906892 | Domestic Cold Water 78
906894 | Domestic Cold Water 79
906896 | Domestic Cold Water 80
906898 | Domestic Cold Water 81
906900 | Domestic Cold Water 82
961931 | Domestic Cold Water 175
961933 | Domestic Cold Water 177
961935 | Domestic Cold Water 180
961937 | Domestic Cold Water 183
961939 | Domestic Cold Water 186
961941 | Domestic Cold Water 188
961943 | Domestic Cold Water 189

# IfcPipeFitting: FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ DE (14)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A C external EX+ DE; sets with these values: 2
Name (FASTLOC_Adapter_RX+, with external thread:FSL A C external EX+ DE:...) | Group
829096 | Domestic Cold Water 29
829108 | Domestic Cold Water 30
829120 | Domestic Cold Water 31
829132 | Domestic Cold Water 32
829144 | Domestic Cold Water 33
829156 | Domestic Cold Water 34
829168 | Domestic Cold Water 35
961185 | Domestic Cold Water 119
961187 | Domestic Cold Water 121
961189 | Domestic Cold Water 122
961191 | Domestic Cold Water 123
961193 | Domestic Cold Water 124
961195 | Domestic Cold Water 125
961197 | Domestic Cold Water 126

# IfcPipeFitting: FASTLOC_Blanking plug EX+:FSL Bp EX+ AT (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL Bp EX+ AT; sets with these values: 2
Name (FASTLOC_Blanking plug EX+:FSL Bp EX+ AT:...) | Group
907000 | Domestic Cold Water 104
907002 | Domestic Cold Water 105
962039 | Domestic Cold Water 234
962041 | Domestic Cold Water 235

# IfcPipeFitting: FASTLOC_Blanking plug EX+:FSL Bp EX+ DE (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL Bp EX+ DE; sets with these values: 2
Name (FASTLOC_Blanking plug EX+:FSL Bp EX+ DE:...) | Group
869389 | Domestic Cold Water 66
869442 | Domestic Cold Water 67
961293 | Domestic Cold Water 162
961295 | Domestic Cold Water 163

# IfcPipeFitting: FASTLOC_Corner EX+:FSL C EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C EX+ AT; sets with these values: 2
Name (FASTLOC_Corner EX+:FSL C EX+ AT:...) | Group
906941 | Domestic Cold Water 137
906943 | Domestic Cold Water 138
906945 | Domestic Cold Water 141
906947 | Domestic Cold Water 143
961984 | Domestic Cold Water 278
961986 | Domestic Cold Water 280
961988 | Domestic Cold Water 284
961990 | Domestic Cold Water 287

# IfcPipeFitting: FASTLOC_Corner EX+:FSL C EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C EX+ DE; sets with these values: 2
Name (FASTLOC_Corner EX+:FSL C EX+ DE:...) | Group
840610 | Domestic Cold Water 15
840858 | Domestic Cold Water 17
841038 | Domestic Cold Water 18
841140 | Domestic Cold Water 20
961238 | Domestic Cold Water 210
961240 | Domestic Cold Water 212
961242 | Domestic Cold Water 216
961244 | Domestic Cold Water 219

# IfcPipeFitting: FASTLOC_Coupling equal EX+:FSL C EQ EX+ AT (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C EQ EX+ AT; sets with these values: 2
Name (FASTLOC_Coupling equal EX+:FSL C EQ EX+ AT:...) | Group
906867 | Domestic Cold Water 164
906869 | Domestic Cold Water 166
906871 | Domestic Cold Water 168
906873 | Domestic Cold Water 170
961910 | Domestic Cold Water 316
961912 | Domestic Cold Water 318
961914 | Domestic Cold Water 320
961916 | Domestic Cold Water 322

# IfcPipeFitting: FASTLOC_Coupling equal EX+:FSL C EQ EX+ DE (8)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C EQ EX+ DE; sets with these values: 2
Name (FASTLOC_Coupling equal EX+:FSL C EQ EX+ DE:...) | Group
827927 | Domestic Cold Water 21
827939 | Domestic Cold Water 22
827951 | Domestic Cold Water 23
827967 | Domestic Cold Water 24
961164 | Domestic Cold Water 244
961166 | Domestic Cold Water 246
961168 | Domestic Cold Water 248
961170 | Domestic Cold Water 250

# IfcPipeFitting: FASTLOC_Coupling reduced EX+:FSL C RE EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C RE EX+ AT; sets with these values: 2
Name (FASTLOC_Coupling reduced EX+:FSL C RE EX+ AT:...) | Group
906875 | Domestic Cold Water 107
906877 | Domestic Cold Water 109
906879 | Domestic Cold Water 111
961918 | Domestic Cold Water 385
961920 | Domestic Cold Water 387
961922 | Domestic Cold Water 389

# IfcPipeFitting: FASTLOC_Coupling reduced EX+:FSL C RE EX+ DE (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL C RE EX+ DE; sets with these values: 2
Name (FASTLOC_Coupling reduced EX+:FSL C RE EX+ DE:...) | Group
828696 | Domestic Cold Water 237
828708 | Domestic Cold Water 239
828720 | Domestic Cold Water 241
961172 | Domestic Cold Water 243
961174 | Domestic Cold Water 247
961176 | Domestic Cold Water 251

# IfcPipeFitting: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT; sets with these values: 2
Name (FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread AT:...)
906992
906994
962035
962037

# IfcPipeFitting: FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE (4)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE; sets with these values: 2
Name (FASTLOC_Double-wall-mounted elbow EX+, with internal thread:FASTLOC_Double-wall-mounted elbow EX+, with internal thread DE:...)
869329
869356
961289
961291

# IfcPipeFitting: FASTLOC_Elbow with female thread EX+:FSL A internal AT (16)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal AT; sets with these values: 2
Name (FASTLOC_Elbow with female thread EX+:FSL A internal AT:...) | Group
906968 | Domestic Cold Water 96
906970 | Domestic Cold Water 97
906972 | Domestic Cold Water 98
906974 | Domestic Cold Water 99
906976 | Domestic Cold Water 100
906983 | Domestic Cold Water 101
906985 | Domestic Cold Water 102
906987 | Domestic Cold Water 103
962011 | Domestic Cold Water 224
962013 | Domestic Cold Water 225
962015 | Domestic Cold Water 227
962017 | Domestic Cold Water 228
962019 | Domestic Cold Water 230
962026 | Domestic Cold Water 231
962028 | Domestic Cold Water 232
962030 | Domestic Cold Water 233

# IfcPipeFitting: FASTLOC_Elbow with female thread EX+:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal DE; sets with these values: 2
Name (FASTLOC_Elbow with female thread EX+:FSL A internal DE:...) | Group
860846 | Domestic Cold Water 58
860858 | Domestic Cold Water 59
860870 | Domestic Cold Water 60
860882 | Domestic Cold Water 61
860894 | Domestic Cold Water 62
961265 | Domestic Cold Water 154
961267 | Domestic Cold Water 155
961269 | Domestic Cold Water 156
961271 | Domestic Cold Water 157
961273 | Domestic Cold Water 158

# IfcPipeFitting: FASTLOC_Elbow with male thread EX+:FSL A internal AT (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal AT; sets with these values: 2
Name (FASTLOC_Elbow with male thread EX+:FSL A internal AT:...) | Group
906953 | Domestic Cold Water 131
906955 | Domestic Cold Water 132
906957 | Domestic Cold Water 133
906959 | Domestic Cold Water 134
906961 | Domestic Cold Water 135
961996 | Domestic Cold Water 213
961998 | Domestic Cold Water 215
962000 | Domestic Cold Water 218
962002 | Domestic Cold Water 221
962004 | Domestic Cold Water 222

# IfcPipeFitting: FASTLOC_Elbow with male thread EX+:FSL A internal DE (10)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL A internal DE; sets with these values: 2
Name (FASTLOC_Elbow with male thread EX+:FSL A internal DE:...) | Group
841754 | Domestic Cold Water 9
841890 | Domestic Cold Water 10
842016 | Domestic Cold Water 11
842142 | Domestic Cold Water 12
842260 | Domestic Cold Water 14
961250 | Domestic Cold Water 149
961252 | Domestic Cold Water 150
961254 | Domestic Cold Water 151
961256 | Domestic Cold Water 152
961258 | Domestic Cold Water 153

# IfcPipeFitting: FASTLOC_ML_bend:FSL ML AT (7)
In: Level 1
Type - Material: FASTLOC EX+ ML
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: FSL ML AT; sets with these values: 2
Name (FASTLOC_ML_bend:FSL ML AT:...) | Group
907030 | Domestic Cold Water 106
907036 | Domestic Cold Water 108
907042 | Domestic Cold Water 110
962069 | Domestic Cold Water 236
962075 | Domestic Cold Water 238
962081 | Domestic Cold Water 240
962087 | Domestic Cold Water 242

# IfcPipeFitting: FASTLOC_ML_bend:FSL ML DE (9)
In: Level 1
Type - Material: FASTLOC EX+ ML
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: FSL ML DE; sets with these values: 2
Name (FASTLOC_ML_bend:FSL ML DE:...) | Group
885876 | Domestic Cold Water 1
885911 | Domestic Cold Water 2
885948 | Domestic Cold Water 3
885988 | Domestic Cold Water 4
907048 | Domestic Cold Water 112
961323 | Domestic Cold Water 165
961329 | Domestic Cold Water 169
961335 | Domestic Cold Water 172
961341 | Domestic Cold Water 174

# IfcPipeFitting: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ AT (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL T thread EX+ AT; sets with these values: 2
Name (FASTLOC_T-piece internal thread EX+:FSL T thread EX+ AT:...) | Group
906858 | Domestic Cold Water 73
906860 | Domestic Cold Water 74
906862 | Domestic Cold Water 75
961901 | Domestic Cold Water 167
961903 | Domestic Cold Water 171
961905 | Domestic Cold Water 173

# IfcPipeFitting: FASTLOC_T-piece internal thread EX+:FSL T thread EX+ DE (6)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL T thread EX+ DE; sets with these values: 2
Name (FASTLOC_T-piece internal thread EX+:FSL T thread EX+ DE:...) | Group
827136 | Domestic Cold Water 13
827152 | Domestic Cold Water 16
827168 | Domestic Cold Water 19
961155 | Domestic Cold Water 113
961157 | Domestic Cold Water 115
961159 | Domestic Cold Water 117

# IfcPipeFitting: FASTLOC_T-piece_EX+:FSL T-Piece EX+ AT (36)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL T-Piece EX+ AT; sets with these values: 2
Name (FASTLOC_T-piece_EX+:FSL T-Piece EX+ AT:...) | Group
906822 | Domestic Cold Water 229
906824 | Domestic Cold Water 226
906826 | Domestic Cold Water 223
906828 | Domestic Cold Water 220
906830 | Domestic Cold Water 202
906832 | Domestic Cold Water 205
906834 | Domestic Cold Water 208
906836 | Domestic Cold Water 211
906838 | Domestic Cold Water 214
906840 | Domestic Cold Water 217
906842 | Domestic Cold Water 199
906844 | Domestic Cold Water 184
906846 | Domestic Cold Water 196
906848 | Domestic Cold Water 187
906850 | Domestic Cold Water 190
906852 | Domestic Cold Water 193
906854 | Domestic Cold Water 178
906856 | Domestic Cold Water 181
961865 | Domestic Cold Water 381
961867 | Domestic Cold Water 378
961869 | Domestic Cold Water 375
961871 | Domestic Cold Water 372
961873 | Domestic Cold Water 354
961875 | Domestic Cold Water 357
961877 | Domestic Cold Water 360
961879 | Domestic Cold Water 363
961881 | Domestic Cold Water 366
961883 | Domestic Cold Water 369
961885 | Domestic Cold Water 351
961887 | Domestic Cold Water 336
961889 | Domestic Cold Water 348
961891 | Domestic Cold Water 339
961893 | Domestic Cold Water 342
961895 | Domestic Cold Water 345
961897 | Domestic Cold Water 330
961899 | Domestic Cold Water 333

# IfcPipeFitting: FASTLOC_T-piece_EX+:FSL T-Piece EX+ DE (36)
In: Level 1
Type - Material: Polyvinyl Difluoride, lead-free gunmetal according to DIN SPEC 2701
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FSL T-Piece EX+ DE; sets with these values: 2
Name (FASTLOC_T-piece_EX+:FSL T-Piece EX+ DE:...) | Group
825953 | Domestic Cold Water 72
826348 | Domestic Cold Water 71
826391 | Domestic Cold Water 70
826399 | Domestic Cold Water 69
826479 | Domestic Cold Water 53
826487 | Domestic Cold Water 54
826495 | Domestic Cold Water 55
826503 | Domestic Cold Water 56
826593 | Domestic Cold Water 57
826601 | Domestic Cold Water 68
826663 | Domestic Cold Water 52
826747 | Domestic Cold Water 27
826755 | Domestic Cold Water 51
826763 | Domestic Cold Water 28
826771 | Domestic Cold Water 49
826779 | Domestic Cold Water 50
827048 | Domestic Cold Water 25
827056 | Domestic Cold Water 26
961119 | Domestic Cold Water 309
961121 | Domestic Cold Water 306
961123 | Domestic Cold Water 303
961125 | Domestic Cold Water 300
961127 | Domestic Cold Water 282
961129 | Domestic Cold Water 285
961131 | Domestic Cold Water 288
961133 | Domestic Cold Water 291
961135 | Domestic Cold Water 294
961137 | Domestic Cold Water 297
961139 | Domestic Cold Water 279
961141 | Domestic Cold Water 264
961143 | Domestic Cold Water 276
961145 | Domestic Cold Water 267
961147 | Domestic Cold Water 270
961149 | Domestic Cold Water 273
961151 | Domestic Cold Water 258
961153 | Domestic Cold Water 261

# IfcPipeFitting: RAUTITAN_Sleeve PX:RTI S PX (16)
In: Level 1
Type - Material: RAUTITAN PX
Pset_EnvironmentalImpactIndicators - Reference: RTI S PX; sets with these values: 2
Name (RAUTITAN_Sleeve PX:RTI S PX:...) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2)
874574 | 23.7 | 0.00035628 | 0.00158591
874578 | 25 | 0.000543179 | 0.0020656
874583 | 27.2 | 0.000834578 | 0.00278571
874589 | 34 | 0.00135247 | 0.00443279
907014 | 23.7 | 0.00035628 | 0.00158591
907016 | 25 | 0.000543179 | 0.0020656
907018 | 27.2 | 0.000834578 | 0.00278571
907020 | 34 | 0.00135247 | 0.00443279
961307 | 23.7 | 0.00035628 | 0.00158591
961309 | 25 | 0.000543179 | 0.0020656
961311 | 27.2 | 0.000834578 | 0.00278571
961313 | 34 | 0.00135247 | 0.00443279
962053 | 23.7 | 0.00035628 | 0.00158591
962055 | 25 | 0.000543179 | 0.0020656
962057 | 27.2 | 0.000834578 | 0.00278571
962059 | 34 | 0.00135247 | 0.00443279

# IfcPipeSegment: Pipe Types:FASTLOC EX+ ML AT bar (134)
In: Level 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC EX+ ML AT bar; sets with these values: 2
Name (Pipe Types:FASTLOC EX+ ML AT bar:...) | InvertElevation (mm) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
888223 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 72
907026 | -6 | 160 | 0.000201032 | 0.00804248 | Domestic Cold Water 106
907028 | -6 | 192 | 0.000201032 | 0.00965097 | Domestic Cold Water 106
907032 | -8 | 180 | 0.000314112 | 0.0113097 | Domestic Cold Water 108
907034 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 108
907038 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 110
907040 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 110
907044 | -13 | 200 | 0.000804127 | 0.0201062 | Domestic Cold Water 112
907046 | -13 | 184 | 0.000804127 | 0.0184977 | Domestic Cold Water 112
907050 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 114
907052 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 114
907054 | 3.7 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 116
907056 | 3.7 | 182.7 | 0.0004908 | 0.0143492 | Domestic Cold Water 116
907058 | 5.7 | 120 | 0.000314112 | 0.00753982 | Domestic Cold Water 118
907060 | 5.7 | 240.3 | 0.000314112 | 0.0150985 | Domestic Cold Water 118
907062 | 7.7 | 120.6 | 0.000201032 | 0.00606202 | Domestic Cold Water 120
907064 | 7.7 | 200 | 0.000201032 | 0.0100531 | Domestic Cold Water 120
907066 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 104
907068 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 105
907070 | -6 | 130.2 | 0.000201032 | 0.00654457 | Domestic Cold Water 101
907072 | -6 | 190.2 | 0.000201032 | 0.00956049 | Domestic Cold Water 102
907074 | -10 | 199.9 | 0.0004908 | 0.0157001 | Domestic Cold Water 103
907076 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 99
907078 | -8 | 221 | 0.000314112 | 0.0138858 | Domestic Cold Water 98
907080 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 97
907082 | -6 | 240.4 | 0.000201032 | 0.0120838 | Domestic Cold Water 96
907084 | -6 | 220 | 0.000201032 | 0.0110584 | Domestic Cold Water 131
907086 | -8 | 219.6 | 0.000314112 | 0.0137979 | Domestic Cold Water 132
907088 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 133
907090 | -10 | 250 | 0.0004908 | 0.019635 | Domestic Cold Water 134
907092 | -13 | 230 | 0.000804127 | 0.0231221 | Domestic Cold Water 135
907094 | -13 | 280 | 0.000804127 | 0.0281487 | Domestic Cold Water 100
907096 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 137
907098 | -8 | 237.5 | 0.000314112 | 0.0149226 | Domestic Cold Water 138
907100 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 138
907102 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 137
907104 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 141
907106 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 141
907108 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 143
907110 | -13 | 227.1 | 0.000804127 | 0.0228306 | Domestic Cold Water 143
907112 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 95
907114 | -10 | 202.5 | 0.0004908 | 0.0159043 | Domestic Cold Water 94
907116 | -8 | 223.9 | 0.000314112 | 0.0140681 | Domestic Cold Water 93
907118 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 92
907120 | -6 | 150 | 0.000201032 | 0.00753982 | Domestic Cold Water 88
907122 | -8 | 150 | 0.000314112 | 0.00942478 | Domestic Cold Water 89
907124 | -10 | 148.7 | 0.0004908 | 0.0116789 | Domestic Cold Water 90
907126 | -13 | 147.5 | 0.000804127 | 0.0148283 | Domestic Cold Water 91
907128 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 83
907130 | -8 | 180.7 | 0.000314112 | 0.0113537 | Domestic Cold Water 84
907132 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 85
907134 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 86
907136 | -13 | 218.4 | 0.000804127 | 0.021956 | Domestic Cold Water 87
907138 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 81
907140 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 80
907142 | -8 | 162.373 | 0.000314112 | 0.0102022 | Domestic Cold Water 79
907144 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 78
907146 | -6 | 209.67 | 0.000201032 | 0.0105392 | Domestic Cold Water 77
907148 | -6 | 174.217 | 0.000201032 | 0.00875708 | Domestic Cold Water 76
907150 | -6 | 140 | 0.000201032 | 0.00703717 | Domestic Cold Water 164
907152 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 164
907154 | -8 | 160 | 0.000314112 | 0.0100531 | Domestic Cold Water 166
907156 | -8 | 179.8 | 0.000314112 | 0.0112972 | Domestic Cold Water 166
907158 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 168
907160 | -10 | 160 | 0.0004908 | 0.0125664 | Domestic Cold Water 168
907162 | -13 | 178 | 0.000804127 | 0.0178945 | Domestic Cold Water 170
907164 | -13 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 170
907166 | -10 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 75
907168 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 75
907170 | -8 | 135 | 0.000314112 | 0.0084823 | Domestic Cold Water 74
907172 | -8 | 170 | 0.000314112 | 0.0106814 | Domestic Cold Water 74
907174 | -6 | 100 | 0.000201032 | 0.00502655 | Domestic Cold Water 73
907176 | -6 | 170 | 0.000201032 | 0.00854513 | Domestic Cold Water 73
907178 | -6 | 115.34 | 0.000201032 | 0.00579762 | Domestic Cold Water 178
907180 | -6 | 120 | 0.000201032 | 0.00603186 | Domestic Cold Water 178
907182 | -8 | 100 | 0.000314112 | 0.00628319 | Domestic Cold Water 178
907184 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 181
907186 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 181
907188 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 181
907190 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 184
907192 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 184
907194 | -6 | 65 | 0.000201032 | 0.00326726 | Domestic Cold Water 184
907196 | -6 | 51.7891 | 0.000201032 | 0.00260321 | Domestic Cold Water 187
907198 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 187
907200 | -6 | 57.2789 | 0.000201032 | 0.00287915 | Domestic Cold Water 187
907202 | -8 | 75 | 0.000314112 | 0.00471239 | Domestic Cold Water 190
907204 | -6 | 50 | 0.000201032 | 0.00251327 | Domestic Cold Water 190
907206 | -10 | 95 | 0.0004908 | 0.00746128 | Domestic Cold Water 190
907208 | -8 | 60 | 0.000314112 | 0.00376991 | Domestic Cold Water 193
907210 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 193
907212 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 193
907214 | -10 | 70.4 | 0.0004908 | 0.0055292 | Domestic Cold Water 196
907216 | -10 | 85 | 0.0004908 | 0.00667588 | Domestic Cold Water 196
907218 | -13 | 185 | 0.000804127 | 0.0185982 | Domestic Cold Water 196
907220 | -6 | 55 | 0.000201032 | 0.0027646 | Domestic Cold Water 199
907222 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 199
907224 | -8 | 130 | 0.000314112 | 0.00816814 | Domestic Cold Water 199
907226 | -8 | 55 | 0.000314112 | 0.00345575 | Domestic Cold Water 202
907228 | -6 | 70 | 0.000201032 | 0.00351858 | Domestic Cold Water 202
907230 | -8 | 110 | 0.000314112 | 0.0069115 | Domestic Cold Water 202
907232 | -10 | 80 | 0.0004908 | 0.00628319 | Domestic Cold Water 205
907234 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 205
907236 | -10 | 135 | 0.0004908 | 0.0106029 | Domestic Cold Water 205
907238 | -13 | 90 | 0.000804127 | 0.00904779 | Domestic Cold Water 208
907240 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 208
907242 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 208
907244 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 211
907246 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 211
907248 | -13 | 165 | 0.000804127 | 0.0165876 | Domestic Cold Water 211
907250 | -13 | 134.6 | 0.000804127 | 0.0135315 | Domestic Cold Water 214
907252 | -13 | 169.6 | 0.000804127 | 0.0170501 | Domestic Cold Water 214
907254 | -8 | 90 | 0.000314112 | 0.00565487 | Domestic Cold Water 214
907256 | -13 | 132.8 | 0.000804127 | 0.0133505 | Domestic Cold Water 217
907258 | -13 | 145 | 0.000804127 | 0.014577 | Domestic Cold Water 217
907260 | -10 | 120 | 0.0004908 | 0.00942478 | Domestic Cold Water 217
907262 | -13 | 130 | 0.000804127 | 0.013069 | Domestic Cold Water 220
907264 | -13 | 135 | 0.000804127 | 0.0135717 | Domestic Cold Water 220
907266 | -13 | 115 | 0.000804127 | 0.0115611 | Domestic Cold Water 220
907268 | -10 | 70 | 0.0004908 | 0.00549779 | Domestic Cold Water 223
907270 | -10 | 105 | 0.0004908 | 0.00824668 | Domestic Cold Water 223
907272 | -10 | 165 | 0.0004908 | 0.0129591 | Domestic Cold Water 223
907274 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 226
907276 | -8 | 65 | 0.000314112 | 0.00408407 | Domestic Cold Water 226
907278 | -8 | 85 | 0.000314112 | 0.00534071 | Domestic Cold Water 226
907280 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 229
907282 | -6 | 90 | 0.000201032 | 0.00452389 | Domestic Cold Water 229
907284 | -6 | 95 | 0.000201032 | 0.00477522 | Domestic Cold Water 229
907286 | -13 | 212.786 | 0.000804127 | 0.0213916 | Domestic Cold Water 82
907639 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 107
907665 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 107
907684 | -8 | 240.6 | 0.000314112 | 0.0151173 | Domestic Cold Water 109
907704 | -10 | 218.9 | 0.0004908 | 0.0171924 | Domestic Cold Water 109
907728 | -10 | 240.5 | 0.0004908 | 0.0188888 | Domestic Cold Water 111
907751 | -13 | 216.3 | 0.000804127 | 0.0217448 | Domestic Cold Water 111

# IfcPipeSegment: Pipe Types:FASTLOC EX+ ML AT coil (133)
In: Level 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 13603011100, 13603011240, 13603011500, 13603021100, 13603031050, 13603041025, 13603011005, 13603021005, 13603031005, 13603041005, 13603051005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: FASTLOC EX+ ML AT coil; sets with these values: 2
Name (Pipe Types:FASTLOC EX+ ML AT coil:...) | InvertElevation (mm) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
962065 | -6 | 160 | 0.000201032 | 0.00804248 | Domestic Cold Water 236
962067 | -6 | 192 | 0.000201032 | 0.00965097 | Domestic Cold Water 236
962071 | -8 | 180 | 0.000314112 | 0.0113097 | Domestic Cold Water 238
962073 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 238
962077 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 240
962079 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 240
962083 | -13 | 200 | 0.000804127 | 0.0201062 | Domestic Cold Water 242
962085 | -13 | 184 | 0.000804127 | 0.0184977 | Domestic Cold Water 242
962089 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 245
962091 | 0.7 | 180 | 0.000804127 | 0.0180956 | Domestic Cold Water 245
962093 | 3.7 | 240 | 0.0004908 | 0.0188496 | Domestic Cold Water 249
962095 | 3.7 | 182.7 | 0.0004908 | 0.0143492 | Domestic Cold Water 249
962097 | 5.7 | 120 | 0.000314112 | 0.00753982 | Domestic Cold Water 252
962099 | 5.7 | 240.3 | 0.000314112 | 0.0150985 | Domestic Cold Water 252
962101 | 7.7 | 120.6 | 0.000201032 | 0.00606202 | Domestic Cold Water 254
962103 | 7.7 | 200 | 0.000201032 | 0.0100531 | Domestic Cold Water 254
962105 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 234
962107 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 235
962109 | -6 | 130.2 | 0.000201032 | 0.00654457 | Domestic Cold Water 231
962111 | -6 | 190.2 | 0.000201032 | 0.00956049 | Domestic Cold Water 232
962113 | -10 | 199.9 | 0.0004908 | 0.0157001 | Domestic Cold Water 233
962115 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 228
962117 | -8 | 221 | 0.000314112 | 0.0138858 | Domestic Cold Water 227
962119 | -8 | 240 | 0.000314112 | 0.0150796 | Domestic Cold Water 225
962121 | -6 | 240.4 | 0.000201032 | 0.0120838 | Domestic Cold Water 224
962123 | -6 | 220 | 0.000201032 | 0.0110584 | Domestic Cold Water 213
962125 | -8 | 219.6 | 0.000314112 | 0.0137979 | Domestic Cold Water 215
962127 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 218
962129 | -10 | 250 | 0.0004908 | 0.019635 | Domestic Cold Water 221
962131 | -13 | 230 | 0.000804127 | 0.0231221 | Domestic Cold Water 222
962133 | -13 | 280 | 0.000804127 | 0.0281487 | Domestic Cold Water 230
962135 | -6 | 240 | 0.000201032 | 0.0120637 | Domestic Cold Water 278
962137 | -8 | 237.5 | 0.000314112 | 0.0149226 | Domestic Cold Water 280
962139 | -8 | 200 | 0.000314112 | 0.0125664 | Domestic Cold Water 280
962141 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 278
962143 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 284
962145 | -10 | 200 | 0.0004908 | 0.015708 | Domestic Cold Water 284
962147 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 287
962149 | -13 | 227.1 | 0.000804127 | 0.0228306 | Domestic Cold Water 287
962151 | -13 | 220 | 0.000804127 | 0.0221168 | Domestic Cold Water 209
962153 | -10 | 202.5 | 0.0004908 | 0.0159043 | Domestic Cold Water 207
962155 | -8 | 223.9 | 0.000314112 | 0.0140681 | Domestic Cold Water 206
962157 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 204
962159 | -6 | 150 | 0.000201032 | 0.00753982 | Domestic Cold Water 198
962161 | -8 | 150 | 0.000314112 | 0.00942478 | Domestic Cold Water 200
962163 | -10 | 148.7 | 0.0004908 | 0.0116789 | Domestic Cold Water 201
962165 | -13 | 147.5 | 0.000804127 | 0.0148283 | Domestic Cold Water 203
962167 | -6 | 180 | 0.000201032 | 0.00904779 | Domestic Cold Water 191
962169 | -8 | 180.7 | 0.000314112 | 0.0113537 | Domestic Cold Water 192
962171 | -8 | 220 | 0.000314112 | 0.013823 | Domestic Cold Water 194
962173 | -10 | 220 | 0.0004908 | 0.0172788 | Domestic Cold Water 195
962175 | -13 | 218.4 | 0.000804127 | 0.021956 | Domestic Cold Water 197
962177 | -10 | 180 | 0.0004908 | 0.0141372 | Domestic Cold Water 188
